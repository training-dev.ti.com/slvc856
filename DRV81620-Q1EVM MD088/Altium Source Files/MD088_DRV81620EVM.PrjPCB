# Altium project MD088_DRV81620EVM.PrjPCB (part 2 of 2)

## Sheet MD088_Hardware.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: David Medis; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 4; Revision: Use project parameter SCH_Rev; SheetNumber: 4; SheetTotal: 4; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
FID1  Fiducial  [Fiducial10-20]  (value not drawn)  (no BOM)
FID2  Fiducial  [Fiducial10-20]  (value not drawn)  (no BOM)
FID3  Fiducial  [Fiducial10-20]  (value not drawn)  (no BOM)
H1  SJ-5303 (CLEAR)  [Bumpon_SJ5003Transparent]
H2  SJ-5303 (CLEAR)  [Bumpon_SJ5003Transparent]
H3  SJ-5303 (CLEAR)  [Bumpon_SJ5003Transparent]
H4  SJ-5303 (CLEAR)  [Bumpon_SJ5003Transparent]
LBL1  THT-14-423-10  Note: Size: 0.65" x 0.20 "  [Label_650x200]
Logo1  CE Mark  [CE_Mark_5mm]  (no BOM)
Logo2  Texas Instruments  [TI_Symbol_Overlay_Medium]  (no BOM)
Logo3  FCC disclaimer  [FCC_disclaimer]  (no BOM)
Logo4  WEEE logo  [WEEE_Minimum]  (no BOM)
Logo5  CAUTION.  READ USER GUIDE BEFORE USE  [IEC_Caution_Small]  (no BOM)
LOGO6  CAUTION HOT SURFACE  [IEC_HotSurface_Small]  (no BOM)
LOGO7  CAUTION HOT SURFACE  [IEC_HotSurface_Small]  (no BOM)
ZZ1  This Assembly Note is for PCB labels only  [AssemblyNoteLabel]  (no BOM)
ZZ2  These assemblies are ESD sensitive, ESD precautions shall be observed.  [AssemblyNote]  (no BOM)
ZZ3  These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable.  [AssemblyNote]  (no BOM)
ZZ4  These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified.  [AssemblyNote]  (no BOM)

### Notes on the sheet
- Variant/Label Table
- Variant
- 001
- Label Text

### Library data of the parts
FID1-FID3 = CMP-0077181-1: Fiducial mark.  There is nothing to buy or mount.
H1-H4 = CMP-0003620-1: Bumpon, Hemisphere, 0.44 X 0.20, Clear; Manufacturer: 3M
LBL1 = CMP-0003625-1: Thermal Transfer Printable Labels, 0.650" W x 0.200" H - 10,000 per roll; Manufacturer: Brady
Logo1 = CMP-0074844-2: Manufacturer: Texas Instruments; SymbolCreator: a0412235; AEC Category: Q200; CompType: IC
Logo2 = CMP-0074838-1: Texas Instrument Corporate Signature; SymbolCreator: a0412235; Lib Reference: TI_Logo
Logo3 = CMP-0074847-1: FCC_disclaimer
Logo4 = CMP-0074769-4: Manufacturer: Texas Instruments; CompType: IC; AEC Category: Q200
Logo5 = CMP-0074836-1: IEC 61010-1 Caution Warning; SymbolCreator: a0412235; Lib Reference: IEC_Caution
LOGO6 LOGO7 = CMP-0074837-2: IEC 61010-1 Hot Surface Warning; Manufacturer: Texas Instruments; SymbolCreator: a0412235; CompType: IC; AEC Category: Q200
ZZ1 = CMP-0003616-3
ZZ2 = CMP-0077236-1
ZZ3 = CMP-0077237-1
ZZ4 = CMP-0077238-1

## Nets that join several sheets
GND: MD088_DRV81620 (67 pins), MD088_ezFET (45 pins), MD088_MCU (46 pins)
MCU_3V3: MD088_DRV81620 (J1.3), MD088_ezFET (J10.10), MD088_MCU (21 pins)
VBAT: MD088_DRV81620 (11 pins), MD088_MCU (D6.2)
IN0: MD088_DRV81620 (U5.23), MD088_MCU (J7.3 TP22.1)
IN1: MD088_DRV81620 (U5.22), MD088_MCU (J7.5 TP23.1)
MCU_UARTRXD: MD088_ezFET (J10.8), MD088_MCU (U1.61)
MCU_UARTTXD: MD088_ezFET (J10.6), MD088_MCU (U1.60)
nSCS: MD088_DRV81620 (U5.1), MD088_MCU (J7.15 TP28.1)
nSLEEP: MD088_DRV81620 (U5.21), MD088_MCU (J7.7 TP24.1)
RST/SBWTDIO: MD088_ezFET (J10.4), MD088_MCU (6 pins)
SCLK: MD088_DRV81620 (U5.2), MD088_MCU (J7.13 TP27.1)
SDI: MD088_DRV81620 (U5.3), MD088_MCU (J7.11 TP26.1)
SDO: MD088_DRV81620 (U5.4), MD088_MCU (J7.9 TP25.1)
TST/SBWTCK: MD088_ezFET (J10.2), MD088_MCU (U1.91)
VBAT_MON: MD088_DRV81620 (D20.1 R97.1 R98.1), MD088_MCU (U1.97)

## Assembly variants
001: not fitted C17 C18 C19 C55 C56 C57 C58 C60 C61 C62 C63 C64 C65 C66 R32 R40 R51 R53 R54 R62