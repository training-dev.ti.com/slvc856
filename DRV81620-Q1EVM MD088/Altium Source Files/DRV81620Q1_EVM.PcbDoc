# Altium PCB DRV81620Q1_EVM.PcbDoc (part 2 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4571 x 3250 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 263 components, 134 nets, 711 pads, 499 vias.
Unrouted connection lines stored in the file: 1.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
PolygonConnect PolygonConnect_6 [All vs IsNamedPolygon('TOP_LAYER_VM_P042')] p89: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_5 [All vs IsNamedPolygon('TOP_LAYER_VM_P044')] p90: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_4 [All vs IsNamedPolygon('TOP_LAYER_VM_P046')] p91: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_3 [All vs IsNamedPolygon('TOP_LAYER_GND_P036') Or  IsNamedPolygon('TOP_LAYER_OUT2_P040') Or  IsNamedPolygon('TOP_LAYER_OUT1_P038')] p92: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_2 [InNet('EZFET_VBUS') vs IsNamedPolygon('TOP_LAYER_EZFET_VBUS_P008')] p93: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_1 [InNetClass('Power-Net') vs IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201')] p94: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect [All] p95: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
RoutingVias ThermalPadVias [IsVia and InAnyComponent] p1: holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62
RoutingVias [All] p2: holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
SilkToBoardRegionClearance [Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)] p1:
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [(HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small')) vs (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))] p1: silktosilkclearance=0
SilkToSilkClearance [All] p2: silktosilkclearance=3.94
SilkToSolderMaskClearance SilkToComponentPadClearance [(IsPad or IsFill or IsRegion) and InAnycomponent] p1: minsilkscreentomaskgap=5 clearancetoexposedcopper=TRUE
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p2: minsilkscreentomaskgap=3.94 clearancetoexposedcopper=FALSE
SolderMaskExpansion [All] p1: expansion=1.97 istentingtop=FALSE
SupplyNets "Schematic Supply Nets_3" [InNet('VIN')] p1: voltage=0.000
SupplyNets "Schematic Supply Nets_7" [InNet('VBAT')] p2: voltage=0.000
SupplyNets "Schematic Supply Nets_6" [InNet('GND')] p3: voltage=0.000
SupplyNets "Schematic Supply Nets_5" [InNet('EZFET_VCC')] p4: voltage=0.000
SupplyNets "Schematic Supply Nets_4" [InNet('MCU_3V3')] p5: voltage=0.000
SupplyNets "Schematic Supply Nets_2" [InNet('EZFET_VBUS')] p6: voltage=0.000
SupplyNets "Schematic Supply Nets_1" [InNet('VM')] p7: voltage=0.000
SupplyNets "Schematic Supply Nets" [InNet('VDD_3V3')] p8: voltage=0.000
UnRoutedNet [All] p1: checkbadconnections=TRUE
Width [All] p1: maxlimit=65 minlimit=6 preferedwidth=8 minimp=50.000000 maximp=50.000000 favimp=50.000000 checkconnectedcopper=TRUE
13 further rules are at their usual default settings.

## Classes and differential pairs
component class MD088_DRV81620: C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C16 C17 C18 C19 C55 C56 C57 C58 C60 C61 C62 C63 C64 C65 C66 D20 F1 J1 J4 J5 J8 J12 J13 J14 J15 J16 J17 J18 J19 J20 J21 J22 J23 J24 J25 J26 J27 J28 J29 L3 R1 R3 R4 R97 R98 SH-J1 SH-J23 SH-J24 SH-J25 SH-J26 SH-J29 SH-J34 TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 TP37 TP38 TP39 TP40 TP41 U4 U5 U7
component class MD088_Hardware: FID1 FID2 FID3 H1 H2 H3 H4 LBL1 Logo1 Logo2 Logo3 Logo4 Logo5 LOGO6 LOGO7 ZZ1 ZZ2 ZZ3 ZZ4
component class Logo: Logo2
component class Label: LBL1
component class FiducialMark: FID1 FID2 FID3
component class AssemblyNote: ZZ1 ZZ2 ZZ3 ZZ4
component class MD088_MCU: C15 C41 C44 C45 C46 C49 C50 C51 C52 C53 C54 C59 D3 D5 D6 D8 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 J6 J7 R9 R18 R19 R30 R31 R32 R37 R39 R40 R41 R43 R45 R47 R48 R49 R51 R52 R53 R54 R80 R81 R82 R83 R84 R85 R86 R87 R88 R90 R91 R92 R93 R94 R95 R96 S1 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J35 TP19 TP22 TP23 TP24 TP25 TP26 TP27 TP28 TP29 TP30 TP31 TP32 TP33 TP34 TP35 TP36 U1 Y2
component class Shunt: SH-J1 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J31 SH-J32 SH-J33 SH-J34 SH-J35 SH-J36
net class Power-Net: EZFET_VBUS EZFET_VCC GND MCU_3V3
component class Header: J1 J6 J10 J14 J15 J16 J17 J20 J21 J22 J23 J26 J27 J28 J29
component class MD088_ezFET: C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C42 C43 C47 C48 D1 D2 J9 J10 J11 L1 L2 R55 R56 R57 R58 R59 R60 R61 R62 R63 R64 R65 R66 R67 R68 R72 R75 R76 R77 R78 SH-J27 SH-J28 SH-J31 SH-J32 SH-J33 SH-J36 U2 U3 U6 Y1
differential pair USB_D: +USB_D_P -USB_D_N
differential pair EZFET_D: +EZFET_D_P -EZFET_D_N

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
C1 "885012206094" WCAP-CSGP_0603_L1.6W0.8H0.8_Reflow 3358,1486 r180 top value=68nF
C2 "885012209073" FP-885012209073_1210-MFG 3378,1390 r180 top value=10µF
C3 "885012206126" FP-885012206126_0603-MFG 3993.03,2152.82 r270 top value=1µF
C4 "885012206126" FP-885012206126_0603-MFG 3334,1158 r270 top value=1µF
C5 "885012206095" 0603 4070,2152.22 r270 top value=0.1uF
C6 "885012206095" 0603 2976,2285 r270 top value=0.1uF
C7 "885012107011" 0805_150 2587,2275 r270 top value=22uF
C8 "885012206114" 0603 3492,1152 r90 top value=0.01uF
C9 "885012205018" FP-885012205018_0402-MFG 3483,1660.69 r90 top value=100nF
C10 "885012206095" 0603 3413,1154 r270 top value=0.1uF
C11 "885012206114" 0603 4150,2152.22 r90 top value=0.01uF
C12 "885012006085" FP-885012006085_0603-MFG 4230,2152.22 r270 top value=1nF
C13 "865080657017" FP-865080657017_RADIAL-MFG 4180,2458 r180 top value=150µF
C14 "865080657017" FP-865080657017_RADIAL-MFG 3869,1159 r180 top value=150µF
C15 "885012206095" 0603 248,1366 r180 top value=0.1uF
C16 "885012006085" FP-885012006085_0603-MFG 3572,1157 r270 top value=1nF
C17 "885012206089" 0603 3693.53,2945.57 r270 bottom value=0.01uF
C18 "885012206089" 0603 3893.27,2948.53 r270 bottom value=0.01uF
C19 "885012206089" 0603 2926.21,333.85 r90 bottom value=0.01uF
C20 "885012106012" FP-885012106012_0603-MFG 1265.47,2695 r0 top value=4.7µF
C21 "885012206095" 0603 1270,2770 r180 top value=0.1uF
C22 "885012005058" FP-885012005058_0402-MFG 445,2670 r180 top value=33pF
C23 "885012006085" FP-885012006085_0603-MFG 445,2820 r180 top value=1nF
C24 "885012005058" FP-885012005058_0402-MFG 445,2720 r180 top value=33pF
C25 "885012206095" 0603 195,2245 r180 top value=0.1uF
C26 "885012005055" 0402 896,1940 r270 top value=10pF
C27 "885012005055" 0402 821,1940 r270 top value=10pF
C28 "885012206048" 0603L 670,2545 r90 top value=0.22uF
C29 "885012206050" FP-885012206050_0603-MFG 195,2095 r0 top value=470nF
C30 "885012206048" 0603L 745,2545 r90 top value=0.22uF
C31 "875105240001" FP-875105240001_SMT_CAP_4MM3_4MM3-MFG 920,2195 r180 top value=10µF
C32 "885012206095" 0603 195,2170 r180 top value=0.1uF
C33 "885012206095" 0603 745,2695 r270 top value=0.1uF
C34 "885012206095" 0603 521,1940 r90 top value=0.1uF
C35 "885012206126" FP-885012206126_0603-MFG 595,2820 r90 top value=1µF
C36 "885012206095" 0603 670,2695 r270 top value=0.1uF
C37 "885012206114" 0603 995,2840 r180 top value=0.01uF
C38 "885012106018" 0603 820,2545 r90 top value=2.2uF
C39 "885012206114" 0603 970,2545 r270 top value=0.01uF
C40 "885012206126" FP-885012206126_0603-MFG 895,2545 r90 top value=1µF
C41 "885012006085" FP-885012006085_0603-MFG 1568,1736 r180 top value=1nF
C42 "885012005055" 0402 1070,2545 r90 top value=10pF
C43 "885012005055" 0402 1220,2545 r90 top value=10pF
C44 "885012005055" 0402 263,941 r180 top value=10pF
C45 "885012005055" 0402 248,1091 r180 top value=10pF
C46 "885012206095" 0603 295.02,549.23 r0 top value=0.1uF
C47 "885012206048" 0603L 1445,2970 r0 top value=0.22uF
C48 "885012206095" 0603 820,2820 r270 top value=0.1uF
C49 "885012206050" FP-885012206050_0603-MFG 482.94,626.9 r0 top value=470nF
C50 "885012206095" 0603 248,1166 r180 top value=0.1uF
C51 "875105240001" FP-875105240001_SMT_CAP_4MM3_4MM3-MFG 204.98,811.41 r0 top value=10µF
C52 "885012206095" 0603 295.02,610.31 r180 top value=0.1uF
C53 "885012206095" 0603 295.02,671.92 r180 top value=0.1uF
C54 "885012206095" 0603 628,1446 r270 top value=0.1uF
C55 "885012206089" 0603 4294.16,887.95 r0 bottom value=0.01uF
C56 "885012206089" 0603 4274.36,424.83 r0 bottom value=0.01uF
C57 "885012206089" 0603 2730.17,333.85 r90 bottom value=0.01uF
C58 "885012206089" 0603 1904.39,2945.5 r270 bottom value=0.01uF
C59 "885012006085" FP-885012006085_0603-MFG 1568,1910 r180 top value=1nF
C60 "885012206089" 0603 2104.6,2938.78 r270 bottom value=0.01uF
C61 "885012206089" 0603 3846.14,333.46 r90 bottom value=0.01uF
C62 "885012206089" 0603 3646.16,333.46 r90 bottom value=0.01uF
C63 "885012206089" 0603 2019.32,346.13 r90 bottom value=0.01uF
C64 "885012206089" 0603 1818.37,346.13 r90 bottom value=0.01uF
C65 "885012206089" 0603 2776.72,2945.65 r270 bottom value=0.01uF
C66 "885012206089" 0603 2975.66,2944.99 r270 bottom value=0.01uF
D1 "150060SS75000" WL-SMCW_RED 245,2445 r270 top value="Super Red"
D2 "150080VS75000" WL-SMCW_Green_0805 145,2445 r270 top value="Bright Green"
D3 "150060SS75000" WL-SMCW_RED 1354.39,426 r90 top value="Super Red"
D5 "150080VS75000" WL-SMCW_Green_0805 394.79,426.48 r90 top value="Bright Green"
D6 "150080VS75000" WL-SMCW_Green_0805 3384.72,2335.12 r90 top value="Bright Green"
D8 "150080VS75000" WL-SMCW_Green_0805 712.26,425 r90 top value="Bright Green"
D10 "150080VS75000" WL-SMCW_Green_0805 1030.04,424 r90 top value="Bright Green"
D11 "150080VS75000" WL-SMCW_Green_0805 1188.94,424 r90 top value="Bright Green"
D12 "150080VS75000" WL-SMCW_Green_0805 1712.25,1088.47 r90 top value="Bright Green"
D13 "150080VS75000" WL-SMCW_Green_0805 1860.45,1088.5 r90 top value="Bright Green"
D14 "150080VS75000" WL-SMCW_Green_0805 2019.86,1087.78 r90 top value="Bright Green"
D15 "150080VS75000" WL-SMCW_Green_0805 2183.27,1088.22 r90 top value="Bright Green"
D16 "150080VS75000" WL-SMCW_Green_0805 1712.25,899.47 r270 top value="Bright Green"
D17 "150080VS75000" WL-SMCW_Green_0805 1860.45,899.5 r270 top value="Bright Green"
D18 "150080VS75000" WL-SMCW_Green_0805 2019.86,898.78 r270 top value="Bright Green"
D19 "150080VS75000" WL-SMCW_Green_0805 2183.27,899.22 r270 top value="Bright Green"
D20 "MMSZ4682-E3-08" SOD-123 4498,2386 r90 top value=2.7V
F1 "0454004.MR" SloBlo452 4356.72,2083.02 r270 top value="4A / 125V"
FID1 "Fiducial" Fiducial10-20 341.35,81.83 r0 top
FID2 "Fiducial" Fiducial10-20 4227.76,85.82 r0 top
FID3 "Fiducial" Fiducial10-20 110,2678 r0 top
H1 "SJ-5303 (CLEAR)" Bumpon_SJ5003Transparent 495.72,283.26 r180 bottom
H2 "SJ-5303 (CLEAR)" Bumpon_SJ5003Transparent 297.4,2950.7 r180 bottom
H3 "SJ-5303 (CLEAR)" Bumpon_SJ5003Transparent 4327.15,2509.73 r180 bottom
H4 "SJ-5303 (CLEAR)" Bumpon_SJ5003Transparent 4125.02,1131.85 r180 bottom
J1 "61300311121" WURTH_61300311121 2998,1209 r270 top
J4 "1888700" FP-1888700_HDR4-MFG 2827,215 r0 top
J5 "1888700" FP-1888700_HDR4-MFG 3794,3058 r180 top
J6 "61300311121" WURTH_61300311121 1280,1657.91 r180 top
J7 "61031621121" FP-61031621121_HDR16-MFG 1901.7,1726 r90 top locked
J8 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 4321,1654 r90 top
J9 "61031421121" FP-61031421121_HDR14-MFG 510,3050.7 r180 top
J10 "61031221121" Wurth_61031221121 691,1676.3 r270 top
J11 "629105150921" FP-629105150921_CONN_PTH_USB_8MM0_5MM6-MFG 1141,3140.93 r180 top
J12 "691101710002" FP-691101710002_TERM_BLK_2-MFG 4393,1009 r90 top
J13 "691101710002" FP-691101710002_TERM_BLK_2-MFG 4391,520 r90 top
J14 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 2677,490 r180 top
J15 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 4104,2752.41 r0 top
J16 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 2977,490 r0 top
J17 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3481,2751 r180 top
J18 "1888700" FP-1888700_HDR4-MFG 2006,3058 r180 top
J19 "1888700" FP-1888700_HDR4-MFG 3744,215 r0 top
J20 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 2156,2760.34 r0 top
J21 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3544,490 r180 top
J22 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 1794,2760 r180 top
J23 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3908,490 r0 top
J24 "1888700" FP-1888700_HDR4-MFG 1918,215 r0 top
J25 "1888700" FP-1888700_HDR4-MFG 2877,3058 r180 top
J26 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 1740,503 r180 top
J27 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3027,2760.34 r0 top
J28 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 2094,503 r0 top
J29 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 2671,2760 r180 top
L1 "742792621" 0603L 1270,2895 r0 top value="140 ohm"
L2 "742792621" 0603L 995,2895 r180 top value="140 ohm"
L3 "7443320100" WE-HCC_1210 3678,2296 r270 top value=1uH
LBL1 "THT-14-423-10" Label_650x200 1444,2284 r0 top
Logo1 "CE Mark" CE_Mark_5mm 2471.57,1296.56 r180 bottom
Logo2 "Texas Instruments" TI_Symbol_Overlay_Medium 1483.17,2667.16 r0 top
Logo3 "FCC disclaimer" FCC_disclaimer 4878.84,3355.01 r180 bottom
Logo4 "WEEE logo" WEEE_Minimum 1906.16,1403.06 r180 bottom
Logo5 "CAUTION.  READ USER GUIDE BEFORE USE" IEC_Caution_Small 2818,1926 r0 top
LOGO6 "CAUTION HOT SURFACE" IEC_HotSurface_Small 2823,1656 r0 top
LOGO7 "CAUTION HOT SURFACE" IEC_HotSurface_Small 2959,1722 r180 bottom
R1 "RC0402FR-07100RL" 0402S 3468,1556 r270 top value=100
R3 "Resistor" 0603L 2935,2376 r0 top value=0
R4 "Resistor" 0603L 2635,2376 r0 top value=0
R9 "560050310009" FP-560050310009_0402-MFG 248,1291 r180 top value=10
R18 "CRCW040247K0JNED" 0402 723,1441 r270 top value=47k
R19 "CRCW040247K0JNED" 0402 1568,1809 r0 top value=47k
R30 "RC0603JR-0710KL" 0603L 1418,1422.69 r270 top value=10k
R31 "RC0603JR-0710KL" 0603L 1513,1528.44 r270 top value=10k
R32 "RC0603JR-0710KL" 0603L 1513,1428.44 r270 top value=10k
R37 "560050310009" FP-560050310009_0402-MFG 248,1241 r0 top value=10
R39 "RC0603JR-0710KL" 0603L 1163,1526 r270 top value=10k
R40 "RC0603JR-0710KL" 0603L 1250.2,1523.56 r270 top value=10k
R41 "RC0603JR-0710KL" 0603L 1333,1526.75 r270 top value=10k
R43 "CRCW06034K99FKEAC" 0603L 3384.7,2194.77 r90 top value=4.99k
R45 "Resistor" 0603L 712.24,283.65 r90 top value=330
R47 "Resistor" 0603L 1030.03,282.65 r90 top value=330
R48 "Resistor" 0603L 1188.92,282.65 r90 top value=330
R49 "Resistor" 0603L 394.45,286.12 r90 top value=330
R51 "RC0603JR-0710KL" 0603L 1163,1426 r270 top value=10k
R52 "RC0603JR-0710KL" 0603L 1250.2,1421 r270 top value=10k
R53 "RC0603JR-0710KL" 0603L 1333,1424.19 r270 top value=10k
R54 "RC0603JR-0710KL" 0603L 1418,1525.25 r270 top value=10k
R55 "RC0402FR-07220KL" 0402 345,2670 r180 top value=220k
R56 "CRCW0402240KFKED" 0402 345,2720 r180 top value=240k
R57 "CRCW040247K0JNED" 0402 345,2820 r180 top value=47k
R58 "RC0603JR-07470RL" 0603 371,1940 r270 top value=470
R59 "RC0603JR-07470RL" 0603 446,1940 r270 top value=470
R60 "RC0402FR-07220KL" 0402 345,2620 r0 top value=220k
R61 "CRCW0402150KFKED" 0402 345,2770 r0 top value=150k
R62 "Resistor" 0603L 670,2820 r270 top value=0
R63 "Resistor" 0603L 745,2820 r270 top value=0
R64 "560050310009" FP-560050310009_0402-MFG 971,1915 r270 top value=10
R65 "560050310009" FP-560050310009_0402-MFG 746,1915 r270 top value=10
R66 "560050310009" FP-560050310009_0402-MFG 671,1915 r270 top value=10
R67 "560050310009" FP-560050310009_0402-MFG 596,1915 r270 top value=10
R68 "Resistor" 0603L 820,2695 r270 top value=0
R72 "CRCW040227R0JNED" 0402L 1120,2545 r270 top value=27
R75 "CRCW040227R0JNED" 0402L 1170,2545 r270 top value=27
R76 "CRCW04021K40FKED" 0402L 820,2385 r270 top value=1.40k
R77 "CRCW04021M00JNED" 0402L 895,2385 r90 top value=1.0Meg
R78 "CRCW040233K0JNED" 0402S 1445,3020 r180 top value=33k
R80 "Resistor" 0603L 1353,286 r90 top value=330
R81 "Resistor" 0603L 1786.33,1019.47 r90 top value=330
R82 "Resistor" 0603L 1936.24,1019.5 r90 top value=330
R83 "Resistor" 0603L 2103.81,1019.31 r90 top value=330
R84 "Resistor" 0603L 2261.56,1019.67 r90 top value=330
R85 "Resistor" 0603L 1786.33,914.47 r90 top value=330
R86 "Resistor" 0603L 1936.24,914.5 r90 top value=330
R87 "Resistor" 0603L 2103.81,914.31 r90 top value=330
R88 "Resistor" 0603L 2261.56,914.67 r90 top value=330
R90 "RC0402FR-07470RL" 0402 1433,1241 r180 top value=470
R91 "RC0402FR-07470RL" 0402 1433,1161 r180 top value=470
R92 "RC0402FR-07470RL" 0402 1433,1116 r180 top value=470
R93 "RC0402FR-07470RL" 0402 1433,1201 r180 top value=470
R94 "CRG0402F4K7" 0402 1433,981 r180 top value=4.70k
R95 "CRG0402F4K7" 0402 1433,1026 r180 top value=4.70k
R96 "CRG0402F4K7" 0402 1433,1066 r180 top value=4.70k
R97 "RG1608P-913-B-T5" 0603L 4498,2167 r180 top value=91.0k
R98 "RC0603JR-0710KL" 0603L 4498,2246 r180 top value=10k
S1 "430481025816" FP-430481025816_SMT_SW_6MM2_6MM2-MFG 1196,1921 r180 top
SH-J1 "60900213421" Wurth_60900213421 4104,2752.41 r180 top
SH-J6 "60900213421" Wurth_60900213421 1903,2076 r0 top
SH-J7 "60900213421" Wurth_60900213421 1903,1976 r0 top
SH-J8 "60900213421" Wurth_60900213421 1903,1876 r0 top
SH-J9 "60900213421" Wurth_60900213421 1903,1776 r0 top
SH-J10 "60900213421" Wurth_60900213421 1903,1676 r0 top
SH-J11 "60900213421" Wurth_60900213421 1903,1576 r0 top
SH-J12 "60900213421" Wurth_60900213421 1903,1476 r0 top
SH-J19 "60900213421" Wurth_60900213421 1903,1376 r0 top
SH-J23 "60900213421" Wurth_60900213421 1740,503 r180 top
SH-J24 "60900213421" Wurth_60900213421 3027,2760.34 r180 top
SH-J25 "60900213421" Wurth_60900213421 2156,2760.34 r180 top
SH-J26 "60900213421" Wurth_60900213421 3544,490 r180 top
SH-J27 "60900213421" Wurth_60900213421 940.97,1674.62 r90 top
SH-J28 "60900213421" Wurth_60900213421 840.97,1674.62 r90 top
SH-J29 "60900213421" Wurth_60900213421 2677,490 r180 top
SH-J31 "60900213421" Wurth_60900213421 740.97,1674.62 r90 top
SH-J32 "60900213421" Wurth_60900213421 540.97,1674.62 r90 top
SH-J33 "60900213421" Wurth_60900213421 640.97,1674.62 r90 top
SH-J34 "60900213421" Wurth_60900213421 2996,1255 r270 top
SH-J35 "60900213421" Wurth_60900213421 1328,1658 r0 top
SH-J36 "60900213421" Wurth_60900213421 437,1673 r90 top
TP1 "5011" Keystone5011 3875,1508 r0 top
TP2 "5010" Keystone5010 3872,1817 r0 top
TP3 "5012" Keystone5012 4037,847 r0 top
TP4 "5011" Keystone5011 3278,531 r270 top
TP5 "5012" Keystone5012 4413,123 r0 top
TP6 "5011" Keystone5011 2418,2504 r270 top
TP7 "5010" Keystone5010 2727,736 r0 top
TP8 "5010" Keystone5010 2926,734 r180 top
TP9 "5010" Keystone5010 3894,2732 r0 top
TP10 "5010" Keystone5010 3693,2750 r180 top
TP11 "5010" Keystone5010 2106,2604 r0 top
TP12 "5010" Keystone5010 3590,743 r90 top
TP13 "5010" Keystone5010 1845,2604 r0 top
TP14 "5010" Keystone5010 3843,742 r0 top
TP15 "5010" Keystone5010 1812,653.43 r0 top
TP16 "5010" Keystone5010 2979,2604 r180 top
TP17 "5010" Keystone5010 2041,653.44 r180 top
TP18 "5010" Keystone5010 2720,2605 r0 top
TP19 "TP_H0.45P0.75" TP_H045P075 819.72,471.06 r0 top
TP22 "5002" Keystone5002 2168,1476 r0 top
TP23 "5002" Keystone5002 2288,1576 r0 top
TP24 "5002" Keystone5002 2168,1676 r0 top
TP25 "5002" Keystone5002 2288,1776 r180 top
TP26 "5002" Keystone5002 2168,1876 r180 top
TP27 "5002" Keystone5002 2288,1976 r180 top
TP28 "5002" Keystone5002 2168,2076 r180 top
TP29 "TP_H0.45P0.75" TP_H045P075 168.44,150 r0 top
TP30 "TP_H0.45P0.75" TP_H045P075 168.44,350 r90 top
TP31 "TP_H0.45P0.75" TP_H045P075 168.44,250 r90 top
TP32 "TP_H0.45P0.75" TP_H045P075 168.41,650 r0 top
TP33 "TP_H0.45P0.75" TP_H045P075 168.44,550 r90 top
TP34 "TP_H0.45P0.75" TP_H045P075 168.44,450 r0 top
TP35 "5011" Keystone5011 154,1936 r0 top
TP36 "5003" Keystone5003 154,1469 r0 top
TP37 "Jumper_2p" Harwin_D3082-05 4506,2946 r270 top
TP38 "Jumper_2p" Harwin_D3082-05 2038,2330 r0 top
TP39 "Jumper_2p" Harwin_D3082-05 2593,1695 r270 top
TP40 "5010" Keystone5010 3136,2370 r90 top
TP41 "5010" Keystone5010 4339,3058 r0 top
U1 "MSP430F5338IPZ" PZT0100A_N 723.16,1008 r0 top locked
U2 "MSP430F5528IRGCT" RGC0064B 533.85,2236.66 r0 top
U3 "TPS73533DRBR" DRB0008A 970,2720 r90 top
U4 "LM9036M-3.3/NOPB" D0008A_N 2782.28,2243.19 r0 top
U5 "DRV81620HTSSOP" PWP0024T-MFG 3268,1706 r270 top
U6 "TPD2E001DRYR" DRY0006A 1135.32,2871.81 r90 top
U7 "TVS3300DRVR" DRV0006A 3569.52,1389.72 r0 top
Y1 "CSTNR4M00GH5L000R0" MuRata_CSTNR 520.36,2531.69 r180 top
Y2 "MS3V-T1R 32.768KHZ +/-20PPM 12.5PF" XTAL_MS3V-T1R 238.55,1014.95 r180 top
ZZ1 "This Assembly Note is for PCB labels only" AssemblyNoteLabel -100,-96 r0 top
ZZ2 "These assemblies are ESD sensitive, ESD precautions shall be observed." AssemblyNote 1122.79,914.92 r0 top
ZZ3 "These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable." AssemblyNote 248,404 r0 bottom
ZZ4 "These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified." AssemblyNote 361.21,971.61 r0 bottom

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
0402 [mm] "0402 from SM-752 data"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -1.22,-0.52 1.22,0.52, body extent -0.55,-0.3 0.55,0.3, height 0.6
0402L [mm] "0402 from SM-752 data"
  rect 0.6x0.5 smd: 1(-0.5,0) 2(0.5,0)
  body extent -0.55,-0.3 0.55,0.3, height 0.6
0402S [mil] "Based on C0402S footprint from PADS legacy"
  rect 15x24 smd: 1(-20,0) 2(20,0)
  body extent -22,-12 22,12, height 24
0603 [mm] "0603 from SM-752 data"
  rect 1x0.95 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.52,-0.69 1.52,0.69, body extent -0.87,-0.47 0.87,0.47, height 1
0603L [mm] "0603 from SM-752 data"
  rect 0.8x0.85 smd: 1(-0.7,0) 2(0.7,0)
  silkscreen extent -0.07,-0.33 0.07,0.33, body extent -0.87,-0.47 0.87,0.47, height 1
0805_150 [mm] "0805 / 1.5 mm height"
  rect 1.15x1.45 smd: 1(-0.9,0) 2(0.9,0)
  silkscreen extent -0.1,-0.8 0.1,0.8, body extent -1.1,-0.72 1.1,0.72, height 1.5
AssemblyNote [mil] "Assembly Note"
AssemblyNoteLabel [mil] "Assembly Note for PCB Labels"
Bumpon_SJ5003Transparent [mil] "3M Hemispherical Bumpon transparent"
  round 1 on Mech4: 0(0,0)
  silkscreen extent -228,-228 228,228, body extent -218,-218 219,218, height 197
CE_Mark_5mm [mil] "Minimum text height for CE Mark"
  silkscreen extent -138,-98 138,98
D0008A_N [mm] "SOIC, 8-Leads, Body 4.9x3.9mm, Pitch 1.27mm, IPC Medium Density"
  oval 1.45x0.6 smd: 1(-2.725,1.905) 2(-2.725,0.635) 3(-2.725,-0.635) 4(-2.725,-1.905) 5(2.725,-1.905) 6(2.725,-0.635) 7(2.725,0.635) 8(2.725,1.905)
  silkscreen extent -3.3,-2.5 0.9,2.5, body extent -3,-2.45 3,2.45, height 1.63
DRB0008A [mm] "VSON-8"
  rrect32% 0.6x0.31 smd: 1(-1.4,0.975) 2(-1.4,0.325) 3(-1.4,-0.325) 4(-1.4,-0.975) 5(1.4,-0.975) 6(1.4,-0.325) 7(1.4,0.325) 8(1.4,0.975)
  rrect7% 1.5x1.75 smd paste-0.75: 9(0,0)
  Top Layer region: -0.7,-0.875 -0.49,-0.875 -0.471,-0.879 -0.455,-0.89 -0.444,-0.906 -0.44,-0.925 -0.44,-0.925 -0.44,-1.65 -0.436,-1.669 -0.425,-1.685 -0.409,-1.696 -0.39,-1.7 -0.39,-1.7 -0.26,-1.7 -0.241,-1.696 -0.225,-1.685 -0.214,-1.669 -0.21,-1.65 -0.21,-1.65 -0.21,-0.925 -0.206,-0.906 -0.195,-0.89 -0.179,-0.879 -0.16,-0.875 -0.16,-0.875 0.16,-0.875 0.179,-0.879 0.195,-0.89 0.206,-0.906 0.21,-0.925 0.21,-0.925 0.21,-1.65 0.214,-1.669 0.225,-1.685 0.241,-1.696 0.26,-1.7 0.26,-1.7 0.39,-1.7 0.409,-1.696 0.425,-1.685 0.436,-1.669 0.44,-1.65 0.44,-1.65 0.44,-0.925 0.444,-0.906 0.455,-0.89 0.471,-0.879 0.49,-0.875 0.49,-0.875 0.7,-0.875 0.719,-0.871 0.735,-0.86 0.746,-0.844 0.75,-0.825 0.75,-0.825 0.75,0.825 0.746,0.844 0.735,0.86 0.719,0.871 0.7,0.875 0.7,0.875 0.49,0.875 0.471,0.879 0.455,0.89 0.444,0.906 0.44,0.925 0.44,0.925 0.44,1.65 0.436,1.669 0.425,1.685 0.409,1.696 0.39,1.7 0.39,1.7 0.26,1.7 0.241,1.696 0.225,1.685 0.214,1.669 0.21,1.65 0.21,1.65 0.21,0.925 0.206,0.906 0.195,0.89 0.179,0.879 0.16,0.875 0.16,0.875 -0.16,0.875 -0.179,0.879 -0.195,0.89 -0.206,0.906 -0.21,0.925 -0.21,0.925 -0.21,1.65 -0.214,1.669 -0.225,1.685 -0.241,1.696 -0.26,1.7 -0.26,1.7 -0.39,1.7 -0.409,1.696 -0.425,1.685 -0.436,1.669 -0.44,1.65 -0.44,1.65 -0.44,0.925 -0.444,0.906 -0.455,0.89 -0.471,0.879 -0.49,0.875 -0.49,0.875 -0.7,0.875 -0.719,0.871 -0.735,0.86 -0.746,0.844 -0.75,0.825 -0.75,0.825 -0.75,-0.825 -0.746,-0.844 -0.735,-0.86 -0.719,-0.871 -0.7,-0.875
  silkscreen extent -1.73,-1.73 1.73,1.73, body extent -1.5,-1.5 1.5,1.5, height 0.77
DRV0006A [mm] "SON, 6-Leads, Body 2x2mm, Pitch 0.65mm, Thermal Pad 1.6x1mm, TI Recommended"
  rrect33% 0.45x0.3 smd: 1(-0.975,0.65) 2(-0.975,0) 3(-0.975,-0.65) 4(0.975,-0.65) 5(0.975,0) 6(0.975,0.65)
  rrect14% 1x0.7 on Top Paste: 7(0,-0.45) 7(0,0.45)
  rrect10% 1x1.6 smd paste-0.5: 7(0,0)
  silkscreen extent -1.05,-1.2 1.05,1.2, body extent -1.05,-1.05 1.05,1.05, height 0.81
DRY0006A [mm] "USON-6"
  rrect67% 0.45x0.3 smd paste-0.05 mask-0.05: 1(-0.275,0.5)
  rrect67% 0.4x0.3 smd paste-0.05 mask-0.05: 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
  body extent -0.5,-0.72 0.5,0.73, height 0.58
FCC_disclaimer [mil]
Fiducial10-20 [mm]
  round 1 smd mask+0.5: 1(0,0)
  Top Layer keep-out circle w1.178: c0,0 r0.5
FP-1888700_HDR4-MFG [mm]
  rrect5% 2x2 hole 1.3 paste-2539.97 mask+0: 1(-7.62,0)
  round 2 hole 1.3 paste-2539.97 mask+0: 2(-2.54,0) 3(2.54,0) 4(7.62,0)
  silkscreen extent -10.77,-4.82 10.26,4.82, body extent -10.36,-4.92 10.36,4.92, height 0.25
FP-61031421121_HDR14-MFG [mm]
  rrect10% 1x3.1 smd paste+0 mask+0: 1(-7.62,-2.7) 2(-7.62,2.7) 3(-5.08,-2.7) 4(-5.08,2.7) 5(-2.54,-2.7) 6(-2.54,2.7) 7(0,-2.7) 8(0,2.7) 9(2.54,-2.7) 10(2.54,2.7) 11(5.08,-2.7) 12(5.08,2.7) 13(7.62,-2.7) 14(7.62,2.7)
  silkscreen extent -8.97,-3.52 8.97,2.62, body extent -9.07,-4.35 9.07,4.35, height 0.25
FP-61031621121_HDR16-MFG [mm]
  rrect10% 1x3.1 smd paste+0 mask+0: 1(-8.89,-2.7) 2(-8.89,2.7) 3(-6.35,-2.7) 4(-6.35,2.7) 5(-3.81,-2.7) 6(-3.81,2.7) 7(-1.27,-2.7) 8(-1.27,2.7) 9(1.27,-2.7) 10(1.27,2.7) 11(3.81,-2.7) 12(3.81,2.7) 13(6.35,-2.7) 14(6.35,2.7) 15(8.89,-2.7) 16(8.89,2.7)
  silkscreen extent -10.16,-3.6 10.16,2.62, body extent -10.26,-4.35 10.26,4.35, height 0.25
FP-430481025816_SMT_SW_6MM2_6MM2-MFG [mm]
  rrect7% 2x1.4 smd paste+0 mask+0: 1(-3.5,2) 2(3.5,2) 3(-3.5,-2) 4(3.5,-2)
  silkscreen extent -5.18,-3.2 3.2,3.2, body extent -4.6,-3.3 4.6,3.3, height 0.25
FP-560050310009_0402-MFG [mm]
  rrect25% 0.4x0.5 smd paste+0 mask+0: 1(-0.45,0) 2(0.45,0)
  silkscreen extent -0.5,-0.63 0.5,0.63, body extent -0.75,-0.38 0.75,0.38, height 0.25
FP-629105150921_CONN_PTH_USB_8MM0_5MM6-MFG [mm]
  rrect25% 0.4x1.35 smd paste+0 mask+0: 1(-1.3,2.335) 2(-0.65,2.335) 3(0,2.335) 4(0.65,2.335) 5(1.3,2.335)
  rrect100% 1.15x1.05 hole 0.75 paste-2539.97 mask+0: 6(-2.225,2.65) 7(2.225,2.65)
  rrect100% 1.35x1.9 hole 1.3 slot 0.75 at 0 deg paste-2539.97 mask+0: 8(-4.175,-0.47) 11(4.173,-0.47)
  round 1.71 smd paste+0 mask+0: 8(-3.699,-0.47) 11(3.699,-0.47)
  rrect6% 1.8x1.9 smd paste+0 mask+0: 9(-1.15,-0.47) 10(1.15,-0.47)
  Top Layer region: 2.6,0.48 4.35,0.48 4.541,0.442 4.704,0.334 4.812,0.171 4.85,-0.02 4.85,-0.02 4.85,-0.92 4.812,-1.111 4.704,-1.274 4.541,-1.382 4.35,-1.42 4.35,-1.42 2.6,-1.42
  Top Layer region: -2.6,-1.42 -4.35,-1.42 -4.541,-1.382 -4.704,-1.274 -4.812,-1.111 -4.85,-0.92 -4.85,-0.92 -4.85,-0.02 -4.812,0.171 -4.704,0.334 -4.541,0.442 -4.35,0.48 -4.35,0.48 -2.6,0.48
  silkscreen extent -3.8,0.86 3.8,3.71, body extent -4.95,-2.7 4.95,3.27, height 0.25
FP-691101710002_TERM_BLK_2-MFG [mm]
  rrect5% 2x2 hole 1.3 paste-2539.97 mask+0: 1(-2.5,-0.5)
  round 2 hole 1.3 paste-2539.97 mask+0: 2(2.5,-0.5)
  silkscreen extent -5.07,-4.65 5.07,4.65, body extent -6.07,-4.75 6.07,4.75, height 0.25
FP-691250610002_CONN_TERM_BLOCK2-MFG [mm]
  rrect4% 2.3x2.3 hole 1.6 paste-2539.97 mask+0: 1(-2.875,1.65)
  round 2.3 hole 1.6 paste-2539.97 mask+0: 2(3.475,1.65)
  silkscreen extent -7.52,-6.3 6.85,6.3, body extent -6.95,-6.4 6.95,6.4, height 0.25
FP-865080657017_RADIAL-MFG [mm]
  rrect5% 4.4x1.9 smd paste+0 mask+0: 1(-4.35,0) 2(4.35,0)
  silkscreen extent -6.3,-5.25 5.25,5.25, body extent -6.8,-5.5 6.8,5.5, height 0.25
FP-875105240001_SMT_CAP_4MM3_4MM3-MFG [mm]
  rrect6% 2.6x1.6 smd paste+0 mask+0: 1(-1.8,0) 2(1.8,0)
  silkscreen extent -3.68,-2.25 2.25,2.25, body extent -3.35,-2.5 3.35,2.5, height 0.25
FP-885012005058_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.53,-0.63 0.53,0.63, body extent -0.85,-0.38 0.85,0.38, height 0.25
FP-885012006085_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77, body extent -1.25,-0.55 1.25,0.55, height 0.25
FP-885012106012_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77, body extent -1.25,-0.55 1.25,0.55, height 0.25
FP-885012205018_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.5,-0.63 0.5,0.63, body extent -0.5,-0.25 0.5,0.25, height 0.55
FP-885012206050_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77, body extent -1.25,-0.55 1.25,0.55, height 0.25
FP-885012206126_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.8,-0.77 0.8,0.77, body extent -1.25,-0.58 1.25,0.58, height 0.25
FP-885012209073_1210-MFG [mm]
  rrect11% 0.9x2.5 smd paste+0 mask+0: 1(-1.55,0) 2(1.55,0)
  silkscreen extent -0.72,-1.4 0.72,1.4, body extent -2.1,-1.5 2.1,1.5, height 0.25
Harwin_D3082-05 [mm] "Shorting Plug, 10.16mm spacing, TH"
  round 1.8 hole 1.3: 1(-5.08,0) 2(5.08,0)
  silkscreen extent -3.9,-0.53 3.9,0.53, body extent -5.6,-0.52 5.61,0.52, height 6.63
IEC_Caution_Small [mil]
  silkscreen extent -107,-93 107,92
IEC_HotSurface_Small [mil]
  silkscreen extent -107,-93 107,92
Keystone5002 [mil] "For Keystone 500x miniature loop terminals"
  round 80 hole 40: 1(0,0)
  silkscreen extent -52,-52 52,52, body extent -49,-49 49,49, height 182
Keystone5003 [mil] "For Keystone 500x miniature loop terminals"
  round 80 hole 40: 1(0,0)
  silkscreen extent -52,-52 52,52, body extent -49,-49 49,49, height 182
Keystone5010 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
Keystone5011 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
Keystone5012 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
Label_650x200 [mil] "Thermal Transfer Label"
  round 1 on Mech13: 0(0,0)
  silkscreen extent -325,-100 325,100, body extent -325,-100 325,100, height 1
MuRata_CSTNR [mm] "SMD, 3-Leads, Body 4.5x2mm, Pitch 1.5mm"
  rrect25% 0.4x2.6 smd: 1(-1.5,0) 2(0,0) 3(1.5,0)
  body extent -2.3,-1.05 2.3,1.05, height 1.2
PWP0024T-MFG [mm]
  rrect22% 1.5x0.45 smd paste+0 mask+0: 1(-2.9,3.575) 2(-2.9,2.925) 3(-2.9,2.275) 4(-2.9,1.625) 5(-2.9,0.975) 6(-2.9,0.325) 7(-2.9,-0.325) 8(-2.9,-0.975) 9(-2.9,-1.625) 10(-2.9,-2.275) 11(-2.9,-2.925) 12(-2.9,-3.575) 13(2.9,-3.575) 14(2.9,-2.925) 15(2.9,-2.275) 16(2.9,-1.625) 17(2.9,-0.975) 18(2.9,-0.325) 19(2.9,0.325) 20(2.9,0.975) 21(2.9,1.625) 22(2.9,2.275) 23(2.9,2.925) 24(2.9,3.575)
  rrect3% 3.4x7.8 smd paste-1000 mask-1000: 25(0,0)
  silkscreen extent -4.32,-4.28 2.25,4.28, body extent -3.75,-4.2 3.75,4.2, height 0.25
PZT0100A_N [mm] "QFP, 100-Leads, Body 14x14mm, Pitch 0.50mm, IPC Medium Density"
  oval 1.45x0.3 smd: 1(-7.725,6) 2(-7.725,5.5) 3(-7.725,5) 4(-7.725,4.5) 5(-7.725,4) 6(-7.725,3.5) 7(-7.725,3) 8(-7.725,2.5) 9(-7.725,2) 10(-7.725,1.5) 11(-7.725,1) 12(-7.725,0.5) 13(-7.725,0) 14(-7.725,-0.5) 15(-7.725,-1) 16(-7.725,-1.5) 17(-7.725,-2) 18(-7.725,-2.5) 19(-7.725,-3) 20(-7.725,-3.5) 21(-7.725,-4) 22(-7.725,-4.5) 23(-7.725,-5) 24(-7.725,-5.5) 25(-7.725,-6) 51(7.725,-6) 52(7.725,-5.5) 53(7.725,-5) 54(7.725,-4.5) 55(7.725,-4) 56(7.725,-3.5) 57(7.725,-3) 58(7.725,-2.5) 59(7.725,-2) 60(7.725,-1.5) 61(7.725,-1) 62(7.725,-0.5) 63(7.725,0) 64(7.725,0.5) 65(7.725,1) 66(7.725,1.5) 67(7.725,2) 68(7.725,2.5) 69(7.725,3) 70(7.725,3.5) 71(7.725,4) 72(7.725,4.5) 73(7.725,5) 74(7.725,5.5) 75(7.725,6)
  oval 0.3x1.45 smd: 26(-6,-7.725) 27(-5.5,-7.725) 28(-5,-7.725) 29(-4.5,-7.725) 30(-4,-7.725) 31(-3.5,-7.725) 32(-3,-7.725) 33(-2.5,-7.725) 34(-2,-7.725) 35(-1.5,-7.725) 36(-1,-7.725) 37(-0.5,-7.725) 38(0,-7.725) 39(0.5,-7.725) 40(1,-7.725) 41(1.5,-7.725) 42(2,-7.725) 43(2.5,-7.725) 44(3,-7.725) 45(3.5,-7.725) 46(4,-7.725) 47(4.5,-7.725) 48(5,-7.725) 49(5.5,-7.725) 50(6,-7.725) 76(6,7.725) 77(5.5,7.725) 78(5,7.725) 79(4.5,7.725) 80(4,7.725) 81(3.5,7.725) 82(3,7.725) 83(2.5,7.725) 84(2,7.725) 85(1.5,7.725) 86(1,7.725) 87(0.5,7.725) 88(0,7.725) 89(-0.5,7.725) 90(-1,7.725) 91(-1.5,7.725) 92(-2,7.725) 93(-2.5,7.725) 94(-3,7.725) 95(-3.5,7.725) 96(-4,7.725) 97(-4.5,7.725) 98(-5,7.725) 99(-5.5,7.725) 100(-6,7.725)
  silkscreen extent -8.1,-8.2 8.1,8.2, body extent -8.01,-8.01 8.01,8.01, height 1.6
RGC0064B [mm] "VQFN-64"
  rrect42% 0.6x0.24 smd mask+0.07: 1(-4.4,3.75) 2(-4.4,3.25) 3(-4.4,2.75) 4(-4.4,2.25) 5(-4.4,1.75) 6(-4.4,1.25) 7(-4.4,0.75) 8(-4.4,0.25) 9(-4.4,-0.25) 10(-4.4,-0.75) 11(-4.4,-1.25) 12(-4.4,-1.75) 13(-4.4,-2.25) 14(-4.4,-2.75) 15(-4.4,-3.25) 16(-4.4,-3.75) 33(4.4,-3.75) 34(4.4,-3.25) 35(4.4,-2.75) 36(4.4,-2.25) 37(4.4,-1.75) 38(4.4,-1.25) 39(4.4,-0.75) 40(4.4,-0.25) 41(4.4,0.25) 42(4.4,0.75) 43(4.4,1.25) 44(4.4,1.75) 45(4.4,2.25) 46(4.4,2.75) 47(4.4,3.25) 48(4.4,3.75)
  rrect42% 0.24x0.6 smd mask+0.07: 17(-3.75,-4.4) 18(-3.25,-4.4) 19(-2.75,-4.4) 20(-2.25,-4.4) 21(-1.75,-4.4) 22(-1.25,-4.4) 23(-0.75,-4.4) 24(-0.25,-4.4) 25(0.25,-4.4) 26(0.75,-4.4) 27(1.25,-4.4) 28(1.75,-4.4) 29(2.25,-4.4) 30(2.75,-4.4) 31(3.25,-4.4) 32(3.75,-4.4) 49(3.75,4.4) 50(3.25,4.4) 51(2.75,4.4) 52(2.25,4.4) 53(1.75,4.4) 54(1.25,4.4) 55(0.75,4.4) 56(0.25,4.4) 57(-0.25,4.4) 58(-0.75,4.4) 59(-1.25,4.4) 60(-1.75,4.4) 61(-2.25,4.4) 62(-2.75,4.4) 63(-3.25,4.4) 64(-3.75,4.4)
  rrect2% 4.25x4.25 smd paste-2.112: 65(0,0)
  body extent -4.5,-4.5 4.5,4.5, height 1
Samtec_HTSW-102-07-G-S [mm] "Samtec 100mil, 1x2, 230 mil above insulator"
  rrect6% 1.65x1.65 hole 1.016: 1(-1.27,0)
  round 1.65 hole 1.016: 2(1.27,0)
  silkscreen extent -2.54,-1.27 2.54,1.27, body extent -2.54,-1.27 2.54,1.27, height 8.38
SloBlo452 [mm] "Littelfuse 452/4 Fuses, recommended land pattern"
  rect 1.96x3.15 smd: 1(-2.455,0) 2(2.455,0)
  silkscreen extent -3.75,-1.88 3.75,1.9, body extent -3.05,-1.35 3.05,1.34, height 2.69
SOD-123 [mm] "On Semi recommended land pattern"
  rect 0.915x1.22 smd: 1(-1.637,0) 2(1.637,0)
  silkscreen extent -2.74,-1.17 2.03,1.17, body extent -1.93,-0.9 1.93,0.9, height 1.35
TI_Symbol_Overlay_Medium [mil]
  silkscreen extent -124,-122 124,120
TP_H045P075 [mm] "TP_H0.45P0.75"
  round 1.5 hole 1.016: 1(0,0)
WCAP-CSGP_0603_L1.6W0.8H0.8_Reflow [mm] "Ceramic Capacitors, body 1.6x0.8mm"
  rect 0.8x0.8 smd: 1(-0.75,0) 2(0.75,0)
  body extent -0.8,-0.4 0.8,0.4, height 0.8
WE-HCC_1210 [mm] "WURTH"
  rect 2.9x5.4 smd: 1(-4.95,0) 2(4.95,0)
  silkscreen extent -6,-5.9 6,5.9, body extent -6,-5.85 6,5.85, height 10
WEEE_Minimum [mil] "WEEElie bin"
  silkscreen extent -95,-172 99,104
WL-SMCW_Green_0805 [mm] "SMD, 2-Leads, Body 2x1.25mm"
  rect 1.1x1.2 smd: 1(-1.05,0) 2(1.05,0)
  silkscreen extent -2.4,-1.1 1.5,1.1, body extent -1,-0.62 1,0.63, height 0.7
WL-SMCW_RED [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8, body extent -0.85,-0.45 0.85,0.45, height 0.8
Wurth_60900213421 [mil] "Shunt, 2.54mm, Black"
  round 1 on Mech3: 0(0,0)
  body extent -98,-48 98,48, height 338
Wurth_61031221121 [mm] "Header, 2.54mm, 6x2, Gold, TH"
  rect 3.1x1 smd: 1(-2.7,6.35) 2(2.7,6.35) 3(-2.7,3.81) 4(2.7,3.81) 5(-2.7,1.27) 6(2.7,1.27) 7(-2.7,-1.27) 8(2.7,-1.27) 9(-2.7,-3.81) 10(2.7,-3.81) 11(-2.7,-6.35) 12(2.7,-6.35)
  silkscreen extent -2.54,-7.62 2.54,8, body extent -3.75,-7.62 3.75,7.62, height 9.6
WURTH_61300311121 [mm] "Header, 2.54mm, 3x1, TH"
  rrect50% 1.65x1.65 hole 1.15: 1(-2.54,0)
  round 1.65 hole 1.15: 2(0,0) 3(2.54,0)
  body extent -3.81,-1.27 3.81,1.27, height 8.54
XTAL_MS3V-T1R [mm] "Micro Crystal Switzerland recommended land pattern"
  rect 1.1x0.6 smd: 1(-2.775,0.45) 2(-2.775,-0.45)
  rect 2.4x1.5 smd: 3(2.775,0)
  silkscreen extent -1.9,-0.74 1.2,0.74, body extent -3.05,-0.74 3.65,0.74, height 1.42

## Part data
C1: library part CMP-0111903-1, "68 nF ±10% 50V Ceramic Capacitor X7R 0603", Capacitance Tolerance=+/-10%, Insulation Resistance=7.4GOhm, Manufacturer="Wurth Elektronik", Operating Temperature Max=125°C, Operating Temperature Min=-55°C, Rated Voltage (DC)=50V
C2: library part CMP-0097489-1, "10 µF ±10% 50V Ceramic Capacitor X7R 1210 (3225 Metric)", Digikey Part Number=732-885012209073TR-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012209073, Operating Temperature Range="-55°C to +125°C", TempCo=15%, Temperature Characteristic=X7R, Tolerance_%=10%, ValueDisplayed=10uF
C3 C4 C35 C40: library part CMP-0120896-1, "1 µF ±10% 50V Ceramic Capacitor X7R 0603 (1608 Metric)", Digikey Part Number=732-885012206126CT-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012206126, Operating Temperature Range="-55°C to +125°C", TempCo=15%, Temperature Characteristic=X7R, Tolerance_%=10%, ValueDisplayed=1uF
C5 C6 C10 C15 C21 C25 C32 C33 C34 C36 C46 C48 C50 C52 C53 C54: library part CMP-0006837-4, "CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=50V, ValueDisplayed=0.1uF
C7: library part CMP-0078153-1, "CAP, CERM, 22 µF, 10 V,+/- 20%, X5R, 0805", Cap_Case=0805, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7621-1-ND, TempCo=X5R, Tolerance_%=20%, Value2=10V, ValueDisplayed=22µF
C8 C11 C37 C39: library part CMP-0079993-1, "CAP, CERM, 0.01 µF, 100 V,+/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", Supplier Part Number 1=45AC8565, TempCo=X7R, Tolerance_%=10%, Value2=100V, ValueDisplayed=0.01µF
C9: library part CMP-0090362-1, "0.1µF ±10% 10V Ceramic Capacitor X7R 0402 (1005 Metric)", Digikey Part Number=732-7513-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012205018, Operating Temperature Range="-55°C to +125°C", TempCo=15%, Temperature Characteristic=X7R, Tolerance_%=10%, ValueDisplayed=100000pF
C12 C16 C23 C41 C59: library part CMP-0097311-1, "1000 pF ±5% 100V Ceramic Capacitor C0G, NP0 0603 (1608 Metric)", Digikey Part Number=732-12187-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012006085, Operating Temperature Range="-55°C to +125°C", TempCo=30ppm/°C, Temperature Characteristic=NP0, Tolerance_%=5%, ValueDisplayed=1nF
C13 C14: library part CMP-0097488-1, "150 µF 50 V Aluminum Electrolytic Capacitors Radial, Can - SMD 2000 Hrs @ 105°C", Digikey Part Number=732-8462-1-ND, Leakage Current=75uA, Manufacturer="Wurth Electronics", Mouser Part Number=710-865080657017, Operating Temperature Range="-55°C to +105°C", Tolerance_%=20%, ValueDisplayed=150uF
C17 C18 C19 C55 C56 C57 C58 C60 C61 C62 C63 C64 C65 C66: library part CMP-0750039-1, "CAP, CERM, 0.01 µF, 50 V,+/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", TempCo=X7R, Tolerance_%=10%, Value2=50V, ValueDisplayed=0.01µF
C20: library part CMP-0097305-1, "4.7 µF ±20% 10V Ceramic Capacitor X5R 0603 (1608 Metric)", Digikey Part Number=732-7909-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012106012, Operating Temperature Range="-55°C to +85°C", TempCo=15%, Temperature Characteristic=X5R, Tolerance_%=20%, ValueDisplayed=4.7uF
C22 C24: library part CMP-0097306-1, "33 pF ±5% 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric)", Digikey Part Number=732-7472-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012005058, Operating Temperature Range="-55°C to +125°C", TempCo=30ppm/°C, Temperature Characteristic=NP0, Tolerance_%=5%, ValueDisplayed=33pF
C26 C27 C42 C43 C44 C45: library part CMP-0006215-2, "CAP, CERM, 10 pF, 50 V, +/- 5%, C0G/NP0, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7469-1-ND, TempCo=C0G/NP0, Tolerance_%=5%, Value1=Unknown, Value2=50V, ValueDisplayed=10pF
C28 C30 C47: library part CMP-0006830-4, "CAP, CERM, 0.22 uF, 16 V, +/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", Supplier Part Number 1=710-885012206048, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=0.22uF
C29 C49: library part CMP-0097608-1, "0.47 µF ±10% 16V Ceramic Capacitor X7R 0603 (1608 Metric)", Digikey Part Number=732-7969-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012206050, Operating Temperature Range="-55°C to +125°C", TempCo=15%, Temperature Characteristic=X7R, Tolerance_%=10%, ValueDisplayed=470nF
C31 C51: library part CMP-0097340-1, "Alum. Polymer Cap 10µF 10V 5.5mmV-Chip WCAP-PSLP Series Lifetime 2000h +105°C", Digikey Part Number=732-6401-1-ND, Leakage Current=300uA, Manufacturer="Wurth Electronics", Mouser Part Number=710-875105240001, Operating Temperature Range="-55°C to +105°C", Tolerance_%=20%, ValueDisplayed=10uF
C38: library part CMP-0006825-5, "CAP, CERM, 2.2 uF, 16 V, +/- 20%, X5R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7915-1-ND, TempCo=X5R, Tolerance_%=20%, Value1=Unknown, Value2=16V, ValueDisplayed=2.2uF
D1 D3: library part CMP-0002893-1, "LED, Super Red, SMD", Color="super red", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-4979-1-ND, Value1=W, Value2=1.9V
D2 D5 D6 D8 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19: library part CMP-0002960-2, "LED, Bright Green, SMD", Color="Bright Green", Manufacturer="Wurth Elektronik", Power_TotalModule=72mW, Supplier Part Number 1=732-4986-1-ND, Value1=0.072W, Value2=2V
D20: library part CMP-0077592-3, "Diode, Zener, 2.7 V, 500 mW, SOD-123", Manufacturer=Vishay-Semiconductor, Power_W=500mW, Value1=0.5W
F1: library part CMP-0003486-2, "Fuse, 4 A, 125VAC/VDC, SMD", Irating_A=4A, Manufacturer=Littelfuse
FID1 FID2 FID3: library part CMP-0077181-1, "Fiducial mark.  There is nothing to buy or mount.", Manufacturer=N/A
H1 H2 H3 H4: library part CMP-0003620-1, "Bumpon, Hemisphere, 0.44 X 0.20, Clear", Manufacturer=3M, Supplier Part Number 1=SJ5303-7-ND
J1 J6: library part CMP-0054796-4, "Header, 2.54 mm, 3x1, Gold, TH", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-5316-ND
J4 J5 J18 J19 J24 J25: library part CMP-0086377-1, "Conn; Term Blk; PCB; Screw; 4; 5.08 mm; Front; 24-14 AWG; 16 A; 250 V; Solder", Current_A=16A, Manufacturer="Phoenix Contact", Voltage_V=400V
J7: library part CMP-0122702-1, "Connector Header Surface Mount 16 position 0.100\" (2.54mm)", Current_A=3A, Digikey Part Number=732-61031621121CT-ND, Manufacturer=Wurth, Mouser Part Number=710-61031621121, Operating Temperature Range="-40°C to +105°C", Voltage_V=250V
J8: library part CMP-0093233-2, "2 Position Wire to Board Terminal Block Horizontal with Board 0.250\" (6.35mm) Through Hole", Current_A=32A, Digikey Part Number=732-691250610002-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-691250610002, Operating Temperature Range="-32°C to +120°C", Voltage_V=450V
J9: library part CMP-0122757-1, "Connector Header Surface Mount 14 position 0.100\" (2.54mm)", Current_A=3A, Digikey Part Number=732-61031421121CT-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-61031421121, Operating Temperature Range="-40°C to +125°C", Voltage_V=250V
J10: library part CMP-0054791-2, "Header, 2.54mm, 6x2, Gold, SMT", Color=Black, Current_A=3A, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-5383-1-ND, Voltage_V=250V
J11: library part CMP-0097752-1, "Conn Micro USB 2.0 Type AB RCP 5 POS 0.65mm Solder RA SMD 5 Terminal 1 Port T/R", Current_A=1A, Digikey Part Number=732-5961-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-629105150921, Operating Temperature Range="-40°C to +85°C", Voltage_V=30V
J12 J13: library part CMP-0121353-1, "2 Position Wire to Board Terminal Block Horizontal with Board 0.197\" (5.00mm) Through Hole", Current_A=16A, Digikey Part Number=732-2026-ND, Manufacturer=Wurth, Mouser Part Number=710-691101710002, Operating Temperature Range="-40°C to +105°C", Voltage=250V
J14 J15 J16 J17 J20 J21 J22 J23 J26 J27 J28 J29: library part CMP-0075483-1, "Header, 100mil, 2x1, Gold, TH", Manufacturer=Samtec, Supplier Part Number 1=SAM8736-ND
L1 L2: library part CMP-0003184-2, "Ferrite Bead, 140 ohm @ 100 MHz, 0.55 A, 0603", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-4663-1-ND, Value1="0.2 ohm", Value2=0.55A, ValueDisplayed="140 ohm"
L3: library part CMP-0063986-1, "Inductor, Shielded Drum Core, Ferrite, 1 uH, 24 A, 0.0012 ohm, SMD", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-2138-1-ND, Value1="0.0012 ohm", Value2=24A, ValueDisplayed=1uH
LBL1: library part CMP-0003625-1, "Thermal Transfer Printable Labels, 0.650\" W x 0.200\" H - 10,000 per roll", Manufacturer=Brady, Supplier Part Number 1=97C5133
Logo1: library part CMP-0074844-2, Manufacturer="Texas Instruments"
Logo2: library part CMP-0074838-1, "Texas Instrument Corporate Signature"
Logo3: library part CMP-0074847-1, "FCC_disclaimer"
Logo4: library part CMP-0074769-4, Manufacturer="Texas Instruments"
Logo5: library part CMP-0074836-1, "IEC 61010-1 Caution Warning"
LOGO6 LOGO7: library part CMP-0074837-2, "IEC 61010-1 Hot Surface Warning", Manufacturer="Texas Instruments"
R1: library part CMP-0026722-1, "RES, 100, 1%, 0.063 W, 0402", Manufacturer="Yageo America", Power_W=63mW, Supplier Part Number 1=311-100LRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=100R, ValueDisplayed=100
R3 R4 R62 R63 R68: library part CMP-0025697-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, PartNumber=CRCW06030000Z0EA, Power_W=100mW, Supplier Part Number 1=541-0.0GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000, ValueDisplayed=0
R9 R37 R64 R65 R66 R67: library part CMP-0097401-1, "Thick Film Resistors 0402 10Ω ±1% 0.125W", Manufacturer="Wurth Electronics", Operating Temperature Range="-55°C to +155°C", Power_W=125mW, TempCo=100ppm/°C, Tolerance_%=1%