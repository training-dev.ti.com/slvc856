# Altium PCB DRV81620Q1_EVM.PcbDoc (part 4 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4571 x 3250 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 263 components, 134 nets, 711 pads, 499 vias.
Unrouted connection lines stored in the file: 1.

## Via types
v1: diameter 24, hole 12, Top Layer to Bottom Layer, tented both sides, 268 vias
v2: diameter 26, hole 12, Top Layer to Bottom Layer, tented both sides, 192 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 37 vias
v4: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
RST/SBWTDIO: C41.2 C59.2 J6.1 J10.4 R18.2 R19.1 U1.96 | length 1543.5
  Top Layer w10: U1.96@565.68,1312.13 565.68,1424.89 573,1432.21 v1(573,1436) ; J6.1@1380,1657.91 1391.24,1669.15 1453.88,1669.15 1475.73,1691 1493.47,1691 C41.2@1538.47,1736 1538.47,1809 C59.2@1538.47,1910
  Top Layer w12: J10.4@841,1570 841,1611.34 854.69,1625.02 887.02,1625.02 v1(888,1626)
  Top Layer w15: v1(696.86,1435.1) 698.59,1433.38 710.94,1433.38 723,1421.31 R18.2@723,1417.38 785.44,1417.38 841,1472.94 J10.4@841,1570
  Signal Layer 2 w12: v1(888,1626) 984.37,1722.37 1315.54,1722.37 1377.04,1660.87 J6.1@1377.04,1656
  Signal Layer 2 w15: v1(573,1436) 695.96,1436 v1(696.86,1435.1)
SCLK: J7.13 TP27.1 U5.2 | length 1692.3
  Top Layer w12: U5.2@3383.16,1818.4 v1(3383.16,1906.83)
  Top Layer w14: J7.13@2008,1976 TP27.1@2288,1976
  Signal Layer 2 w12: TP27.1@2288,1976 2468,2156 3218,2156 3380.9,1988.01 3383.1,1985.75 3383.22,1985.61 3387.09,1981.74 3387.09,1920.96 3385.45,1919.32 3385.45,1909.13 v1(3383.16,1906.83)
SCLK_MCU: R93.2 U1.62 | length 475.8
  Top Layer w8: U1.62@1027.29,988.32 1028.02,989.04 1081.22,989.04 v1(1082.94,990.77) ; v1(1361.64,1208.31) 1364.7,1205.25 1379.38,1205.25 1383.63,1201 1408.68,1201 R93.2@1408.89,1201.21
  Bottom Layer w8: v1(1082.94,990.77) 1300.48,1208.31 v1(1361.64,1208.31)
SDI: J7.11 TP26.1 U5.3 | length 1689.6
  Top Layer w12: U5.3@3357.57,1820.17 3357.57,1922.13 3363.09,1927.66 v1(3363.09,1930.91)
  Top Layer w14: J7.11@2008,1876 TP26.1@2168,1876
  Signal Layer 2 w12: TP26.1@2168,1866 TP26.1@2171.83,1869.83 ; TP26.1@2168,1876 2268,1876 2528,2136 3198,2136 3358,1976 3358,1966.91 3363.09,1961.81 v1(3363.09,1930.91)
SDI_MCU: R91.2 U1.65 | length 454.4
  Top Layer w8: U1.65@1027.29,1047.37 1070.42,1047.37 1095.63,1022.16 1150.78,1022.16 v1(1151.81,1023.19) ; v1(1361.64,1168.31) 1364.7,1165.25 1379.38,1165.25 1383.63,1161 1406.34,1161 R91.2@1406.58,1161.23
  Bottom Layer w8: v1(1151.81,1023.19) 1151.81,1024.92 1295.2,1168.31 v1(1361.64,1168.31)
SDO: J7.9 TP25.1 U5.4 | length 1704.1
  Top Layer w12: v1(3331.23,1882.77) 3331.6,1882.4 3331.6,1820.55 U5.4@3331.98,1820.17
  Top Layer w14: J7.9@2008,1776 TP25.1@2278,1776
  Signal Layer 2 w12: TP25.1@2278,1776 2278,1796 2279.6,1796 2297.01,1813.41 2297.01,1815.01 2308,1826 2308,1876 2538,2106 3188,2106 3331.23,1962.77 v1(3331.23,1882.77)
SDO_MCU: R92.2 U1.66 | length 420
  Top Layer w8: U1.66@1027.29,1067.06 1073.18,1067.06 1088.93,1051.31 1206.69,1051.31 v1(1208,1050) ; v1(1361.64,1123.31) 1364.7,1120.25 1379.38,1120.25 1384.26,1115.37 R92.2@1406.58,1115.37
  Bottom Layer w8: v1(1208,1050) 1281.31,1123.31 v1(1361.64,1123.31)
T_RST_RST: R65.1 U2.43 | length 420.5
  Top Layer w10: U2.43@707.07,2285.87 707.35,2285.6 727.4,2285.6 728,2285 v1(755,2285) ; R65.1@746,1932.72 747.97,1932.72 763.32,1948.07 763.32,1952.32 v1(766,1955)
  Signal Layer 1 w10: v1(755,2285) 755,2283.07 773.13,2264.94 773.13,1965.91 766,1958.79 v1(766,1955)
T_TEST_TCKC: R64.1 U2.44 | length 535.1
  Top Layer w10: U2.44@707.07,2305.56 740.38,2305.56 744.7,2309.87 781.34,2309.87 786.21,2305 v1(790,2305) ; v1(941,1980) 943.68,1977.32 943.68,1958.07 966.16,1935.59 968.13,1935.59 R64.1@971,1932.72
  Signal Layer 1 w10: v1(790,2305) 941,2154 v1(941,1980)
TST/SBWTCK: J10.2 U1.91 | length 549.6
  Top Layer w10: v1(642.17,1360.45) 645.29,1360.45 663.76,1341.99 663.76,1312.48 U1.91@664.1,1312.13 ; J10.2@941,1570 943,1568 v1(943,1396)
  Signal Layer 2 w10: v1(642.17,1360.45) 907.45,1360.45 v1(943,1396)
USB_D_N: J11.2 R72.1 U6.3 | length 544.7
  Top Layer w8: J11.2@1166.59,3049 1166.59,2991.21 1198.15,2959.65 1198.15,2916.01 1186.19,2904.05 1186.19,2889.21 1160.86,2863.87 1156.91,2863.87 1155,2861.97 1155,2816.85 1154.84,2816.69 1154.84,2810.07 1169.91,2795 v1(1170,2795)
  Top Layer w15: R72.1@1120,2564.69 v1(1120,2615)
  Signal Layer 1 w15: v1(1120,2615) 1170,2665 v1(1170,2795)
USB_D_P: J11.3 R75.1 U6.2 U6.5 U6.6 | length 567.1
  Top Layer w8: U6.6@1115.63,2883.62 U6.5@1135.31,2883.62 ; v1(1120,2795) 1120.09,2795 1135.16,2810.07 1135.16,2824.85 1135.31,2825 U6.5@1135.31,2883.62 ; J11.3@1141,3049 1141,2980.61 1172.56,2949.05 1172.56,2926.61 1167.87,2921.92 1155.08,2921.92 1142.19,2909.03 1142.19,2898.69 1137.22,2893.73 1137.22,2885.53 U6.5@1135.31,2883.62
  Top Layer w15: R75.1@1170,2564.69 v1(1170,2615)
  Signal Layer 2 w15: v1(1120,2795) 1120,2665 v1(1170,2615)
VBAT: C3.1 C5.1 C6.1 C11.2 C12.1 C13.2 D6.2 F1.1 L3.1 R3.2 R97.2 TP40.1 | length 77.5
  Top Layer w15: C3.1@3993.03,2182.35 3993.71,2183.03 4069.32,2183.03 C5.1@4070,2183.72
  other v1: 3009,2317 2994,2373 3387,2424 3462,2424 3406,2508 3462,2524
VBAT_MON: D20.1 R97.1 R98.1 U1.97 | length 5718.2
  Top Layer w8: U1.97@545.99,1312.13 545.99,1128.01 683.25,990.75 813.25,990.75 v1(933,871)
  Top Layer w10: D20.1@4498,2321.53 4525.56,2293.97 R98.1@4525.56,2246 R97.1@4525.56,2167 4523,2164.44 v1(4523,2126)
  Signal Layer 2 w8: v1(933,871) 1076,871 1269,678 1685.5,678 1750.5,743 2137,743 2220,826 3732.66,826 3745.66,813 3892.66,813 3912.16,793.5 4105.5,793.5 4309,997 4309,1357 4523,1571 v1(4523,2126)
VDD: C9.1 R1.1 U5.24 | length 66.5
  Top Layer w8: U5.24@3408.75,1593.6 3445.9,1593.6 3463.5,1576 R1.1@3468,1576
VDD_3V3: C7.1 J1.1 R4.1 | length 2501.7
  Top Layer w20: v1(2518,2316) 2519.08,2316 2524.65,2310.43 C7.1@2587,2310.43 ; v1(2575,2365) 2576.08,2365 2580.35,2369.27 2601.69,2369.27 2607.44,2375.02 R4.1@2607.44,2376
  Signal Layer 2 w20: v1(2575,2365) 2574.23,2364.23 2566.23,2364.23 v1(2518,2316) 2388,2186 2108,2186 2058,2136 2058,1346 2138,1266 2951.62,1266 2994.62,1309 J1.1@2998,1309
VIN: F1.2 J8.2 TP2.1 | length 206.5
  Bottom Layer w50: TP2.1@3872,1817 3874.5,1819.5 3990.5,1819.5 v1(4052,1881)
  other v1: 4092,1636 4202,1636 4312,1636 4374.69,1636 4487,1636 4037,1706 4127,1711 4252,1711 4450.69,1716 4347,1721 4082,1786 4477,1786 4374.69,1791 4167,1795 4127,1881 4227,1881 4327,1881 4450.69,1881
VM: C1.2 C2.2 C4.1 C8.2 C10.1 C14.2 C16.1 J4.1 J5.1 J14.2 J15.2 J18.1 J19.1 J20.2 J21.2 J24.1 J25.1 J26.2 J27.2 L3.2 TP41.1 U5.20 U7.4 U7.5 U7.6 | length 11238.3
  Top Layer w10: U5.20@3306.39,1591.83 3306.39,1547.61 v1@3308,1546
  Top Layer w15: U7.4@3607.9,1364.13 U7.6@3607.9,1415.31 ; U7.5@3607.9,1389.72 3646.06,1389.72
  Top Layer w40: J21.2@3494,483.25 J21.2@3494,490 ; C16.1@3571,1187.53 C16.1@3572,1186.53 3572,1213.57 3595.43,1237 3678.57,1237 3702,1213.57 3702,1163.26 C14.2@3697.74,1159
  Bottom Layer w40: J26.2@1690,503 1618,431 J24.1@1618,215 1618,123.43 1641.43,100 2412,100 J4.1@2527,215 ; J20.2@2210.78,2755.57 J20.2@2206,2760.34 2306,2860.34 J18.1@2306,3058 2381.94,3133.94 3101.06,3133.94 J25.1@3177,3058 ; J14.2@2627,481 2626.15,481.85 2618.85,481.85 2527,390 J4.1@2527,215 ; J27.2@3077,2760.34 3177,2860.34 J25.1@3177,3058 ; J21.2@3487.25,490 J21.2@3494,490 J21.2@3494,489.41 ; v1(3641,2171) v1(3698,2171) 4047,2520 4331,2520 ; J15.2@4154,2751.82 4154,2753.59 4032,2875.59 4032,2996 J5.1@4094,3058 ; J4.1@2527,215 2634,108 3337,108 J19.1@3444,215 3444,333.81 3494,383.81 J21.2@3494,489.41 ; J25.1@3177,3058 3264,3145 4007,3145 J5.1@4094,3058 ; J21.2@3494,489.41 3572.77,410.64 4082.51,410.64 4136.95,356.2 4459.67,356.2 4478.06,374.59 4478.06,1591.2 4412.69,1656.57 4412.69,2438.31 4331,2520 ; J5.1@4094,3058 TP41.1@4339,3058 4339,2528 4331,2520
  other v1: 3651.08,1491.63 3307.19,1546.81 3658,1556 3703,1602 3658,1656 3703,1702 3658,1751.09 3703,1802 3658,1856 3703,1902 3658,1956
pads on no net: FID1.1 FID2.1 FID3.1 H1.0 H2.0 H3.0 H4.0 J9.6 J9.10 J9.12 J9.13 J9.14 J11.4 LBL1.0 SH-J1.0 SH-J6.0 SH-J7.0 SH-J8.0 SH-J9.0 SH-J10.0 SH-J11.0 SH-J12.0 SH-J19.0 SH-J23.0 SH-J24.0 SH-J25.0 SH-J26.0 SH-J27.0 SH-J28.0 SH-J29.0 SH-J31.0 SH-J32.0 SH-J33.0 SH-J34.0 SH-J35.0 SH-J36.0 U1.1 U1.2 U1.3 U1.4 U1.5 U1.6 U1.7 U1.8 U1.17 U1.18 U1.22 U1.23 U1.24 U1.28 U1.30 U1.31 U1.32 U1.33 U1.39 U1.40 U1.41 U1.48 U1.49 U1.58 U1.59 U1.68 U1.72 U1.73 U1.74 U1.75 U1.77 U1.78 U1.79 U1.80 U1.81 U1.82 U1.84 U1.85 U1.86 U1.92 U1.93 U1.94 U1.95 U1.98 U1.99 U1.100 U2.3 U2.4 U2.5 U2.6 U2.7 U2.8 U2.10 U2.12 U2.13 U2.18 U2.19 U2.22 U2.23 U2.24 U2.25 U2.26 U2.27 U2.28 U2.29 U2.30 U2.31 U2.32 U2.33 U2.34 U2.35 U2.36 U2.41 U2.42 U2.45 U2.46 U2.47 U2.48 U3.2 U3.6 U3.7 U7.7@3569.52,1372 U7.7@3569.52,1407.44

## Polygon pours and split planes (outlines as drawn)
GND on Bottom Layer "BOTTOM_LAYER_GND_P301" (solid, remove dead copper, pour order 301): 15.16,14.82 4584.16,14.82 4584.16,3253.82 15.16,3253.82
VM on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 300): 3880,1512 3880,1714 3740,1854 3740,1956 3781,1997 3867,1997 3879,2009 3881.28,2047.72 3867,2062 3609,2062 3562,2015 3562,1660 3521,1619 3300,1619 3293,1612 3293,1542 3300,1535 3494,1535 3547,1482 3850,1482
VBAT on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 296): 3484,2559 3533,2510 3533,2341 3477,2286 2969.5,2286 2906.5,2349 2906.5,2414 3051.5,2559
VIN on Bottom Layer "BOTTOM_LAYER_VIN_P284" (solid, remove dead copper, pour order 284): 4007,1599 4007,1994 4032,2019 4515,2019 4548,1987 4548,1599
GND on Top Layer "TOP_LAYER_GND_P298" (solid, remove dead copper, pour order 298): 13.78,3241 4575,3241 4575,4 6,4
VM on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 291): 3298,1622 3297,1621 3297,1542 3301,1538 3301,1201 3355,1147 3793,1147 3864,1218 3864,1536 3957,1629 3957,1991 3763,2185 3600,2185 3600,1335 3529,1264 3410,1264 3346,1328 3346,1487 3315,1518 3315,1620 3313,1622 3312,1622
VIN on Top Layer "TOP_LAYER_VIN_P288" (solid, remove dead copper, pour order 288): 4004.93,2032.93 4018,2046 4548,2046 4548,1609 4004.93,1609
EZFET_USB_Shield on Top Layer "TOP_LAYER_EZFET_USB_SHIELD_P302" (solid, remove dead copper, pour order 302): 1286,3090.65 1459.19,3090.65 1459.19,2929 1286,2929
VDD_3V3 on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 294): 2542,2398 2530,2386 2530,2304 2545,2289 2617,2289 2626,2298 2626,2395 2623,2398
VBAT on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 292): 3362,2359 3362,2526 3417,2581 3725,2581 3835,2692 3922,2692 4107,2507 4107,2297 4176,2228 4480,2228 4495,2213 4495,2159 4489,2153 4036,2153 3839,2350 3371,2350
VBAT on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 295): 2945.67,2305.67 2945.67,2419.67 2981,2455 3168,2455 3206,2417 3206,2328 3169,2291 3003,2291.72 2959.61,2291.72
GND on Signal Layer 2 "SIGNAL_LAYER_2_GND_P275" (solid, remove dead copper, pour order 275): 15.16,14.82 4584.16,14.82 4584.16,3253.82 15.16,3253.82
GND on Signal Layer 1 "SIGNAL_LAYER_1_GND_P184" (solid, remove dead copper, pour order 184): 13.78,3241 4575,3241 4575,4 6,4

## Keep-outs
Keep-Out Layer:
  text ".Layer_Name" at 575,-2292.49 h55

## Other copper
Top Layer:
  region net EZFET_USB_Shield: 930,3223.2 930,3219.75 930,3000 1070.8,3000 1070.8,3082 1093.89,3082 1212.83,3082 1212.83,3005.31 1266.51,3005.31 1266.51,3006.8 1363.6,3006.8 1362,3222.75 1354.61,3222.75
  region net VM: 3296,1621 3296,1540 3299,1537 3299,1449 3311,1437 3341,1437 3344,1440 3344,1487 3316,1515 3316,1620 3314,1622 3297,1622
  region net VDD: 3399,1621 3399,1562 3405,1556 3473,1556 3494,1577 3494,1649 3490,1653 3474,1653 3444,1623 3401,1623
  text ".Layer_Name" at 575,-2292.49 h55
Signal Layer 1:
  text "Signal Layer 1" at 509,-2290.01 h60
Signal Layer 2:
  text "Signal Layer 2" at 574,-2296.01 h60
Bottom Layer:
  region net EZFET_USB_Shield: 1364.4,2999 920,2999 920,3223 1364.4,3223
  text ".Layer_Name" at 575,-2292.49 h55

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  circle w10: c94.25,765.47 r5.29
  circle w10: c912.57,2636.82 r5.29
  circle w10: c3050,1365 r6.4
  circle w10: c377,1244 r4.12
  circle w10: c1454.06,1657.03 r4.24
  lines w5: 4091,807 4091,810 ; 4483,2380.07 4513,2380.07 4498,2380.07 ; 4498,2370.07 4498,2380.07 ; 4498,2410.07 4498,2395.07 4483,2395.07 ; 4483,2395.07 4498,2380.07 ; 4483,2395.07 4513,2395.07 4498,2380.07 ; 4483,2395.07 4498,2380.07
  lines w10: 880,3105 880,3178.52 ; 1019,1728.24 1019,1801.76 ; 2212.15,1476 2348,1476 ; 2212.15,1676 2279,1676 ; 2219.15,1877 2343,1877 ; 2224.15,2076 2339,2076 ; 3384,2421 3414,2421 3399,2421 ; 3399,2451 3399,2436 ; 4091,807 4138,760 ; 4091,889.3 4091,994 4139,1042 ; 3399,2421 3414,2436 3399,2436 ; 3399,2421 3384,2436 3399,2436 ; 3399,2421 3399,2411 3399,2421 ; 1643.61,763 1643.61,1226 2318.61,1226 2318.61,763 1643.61,763 ; 3100.41,1461.7 3503.7,1461.7 3503.7,1886.57 3100.41,1886.57 3100.41,1461.7
  lines w20: 1706,2821.59 1706,3004.41 ; 1847,2675.17 1847,2708.83 ; 1880,2821.59 1880,3004.41 ; 2106,2821.59 2106,3004.41 ; 2107,2675.17 2107,2708.83 ; 2241,2814.59 2241,2947 2302,3008 ; 2579,2817.59 2579,3000.41 ; 2721,2676.17 2721,2709.83 ; 2728,662 2728,686.66 ; 2753,2817.59 2753,3000.41 ; 2979,2817.59 2979,3000.41 ; 2981,2674.17 2981,2707.83 ; 3114,2810.59 3114,2943 3175,3004 ; 3433.56,2806.45 3512.93,2998.06 3491,3051 ; 3578.09,2800.57 3664.85,3010.03 ; 3585.17,2748 3618.83,2748 ; 3924.56,2993.55 3985,2880 ; 3939,1502 4245,1502 ; 3947,1816 4193,1816 ; 3966.17,2744 3999.83,2744 ; 4133,2994 4161,2966 4161,2808.17 ; 4416,280 4416,382
  text "VM" at 4292,3139 h80
  text "GND" at 3347.04,2883 h80 r90
  text "OUT2_D" at 3839,2811.15 h80
  text "GND" at 4471,2793 h50 r90
  text "For EZFET-LITE  / Flashing Only" at 141,2756 h25 r90
  text "4 D" at 2922,2715.34 h80 r90
  text "4 S" at 2829.06,2714 h80 r90
  text "6 S" at 1952.06,2712 h80 r90
  text "6 D" at 2048.06,2711 h80 r90
  text "VM" at 2314,2706 h80 r90
  text "VM" at 3186,2706 h80 r90
  text "VM" at 4257,2701 h80 r90
  text "GND" at 2565.04,2687 h80 r90
  text "GND" at 1685.04,2682 h80 r90
  text "GND" at 3374.04,2670 h80 r90
  text "OUT2_S" at 3484,2628.15 h80
  text "OUT4_S" at 2560,2479.5 h45
  text "OUT6_S" at 1690,2478.5 h45
  text "OUT4_D" at 2887,2477.5 h45
  text "OUT6_D" at 2022,2475.5 h45
  text ".PRJ_Num_and_Rev" at 1310.42,2397.91 h50
  text "1" at 330,2395 h25
  text "GND" at 2341.98,2373.02 h80
  text "LDO" at 2719,2358.72 h60
  text "MSP430F5528" at 391,2325 h27
  text ".EVM_Orderable" at 1136.35,2255.2 h100
  text "VBAT" at 3072.44,2251.45 h35
  text "GND" at 1966,2242 h50
  text "RST" at 1119,2077 h60
  text "nSCS" at 2359,2066 h40
  text "SCLK" at 2359,1958 h40
  text ".DRV_PartNumber" at 3115.36,1903 h33
  text "VIN" at 3821.99,1898.15 h40
  text "SDI" at 2359,1862 h40
  text "GND" at 78,1776 h60
  text "SDO" at 2359,1759 h40
  text "PUSH" at 1116.91,1728.9 h25
  text "RST" at 1372.76,1726.38 h25
  text "nSLEEP" at 2297,1665 h40
  text "GND" at 2676,1632 h50 r90
  text "GND" at 3822,1589 h40
  text "IN1" at 2359,1558 h40
  text "3V3" at 78,1536 h60
  text "HIGH" at 1008,1506 h35
  text "IN0" at 2359,1459 h40
  text "GND" at 458,1406 h35 r90
  text "LOW" at 1038,1406 h35
  text "GND" at 2091.27,1330.76 h40
  text "GND" at 4307,1307.18 h100
  text "LDO_3V3" at 2628,1289.13 h80
  text "ID1" at 1268,1287.66 h35 r90
  text "ID0" at 1178,1276 h35 r90
  text "ID2" at 1348,1276 h35 r90
  text "ID3" at 1438,1276 h35 r90
  text "ID4" at 1528,1276 h35 r90
  text "CHANNEL STATUS" at 1720,1236.78 h65
  text "VDD" at 3067,1176 h80
  text "CH6" at 1677.88,1164.57 h35
  text "CH4" at 1822.72,1164.57 h35
  text "CH2" at 1978,1164 h35
  text "CH0" at 2141.92,1164.42 h35
  text "MCU_3V3" at 2624,1091.13 h80
  text "GND" at 4197.38,1071.61 h80 r90
  text "MSP430F5338" at 506,928 h40
  text "+" at 237.99,842.48 h40
  text "-" at 160.55,840.03 h40
  text "+" at 299.47,839.79 h40
  text "-" at 76.19,833.75 h40
  text "OUT3_D" at 3426,831.66 h40
  text "OUT3_S" at 3715,829.66 h40
  text "OUT5_D" at 2544,824.5 h45
  text "OUT5_S" at 2853,822.5 h45
  text "CH5" at 1813.26,780 h35
  text "CH7" at 1667.01,778.67 h35
  text "CH3" at 1976.79,779.34 h35
  text "CH1" at 2146.31,778.43 h35
  text "OUT0_HS" at 4188.62,762 h70 r90
  text "OUT7_S" at 2111,642.6 h60
  text "OUT7_D" at 1529,638.6 h60
  text "GND" at 3205.2,614.92 h80
  text "GND" at 4195.45,591.94 h80 r90
  text "VM" at 2645,548 h80 r90
  text "5 D" at 2755.04,548 h80 r90
  text "5 S" at 2949.04,548 h80 r90
  text "GND" at 3055.04,548 h80 r90
  text "VM" at 3516,548 h80 r90
  text "3 S" at 3875.06,548 h80 r90
  text "3 D" at 3618.06,547 h80 r90
  text "GND" at 3981.04,547 h80 r90
  text "VM" at 1632,454 h80 r90
  text "7 S" at 1985.04,453 h80 r90
  text "7 D" at 1899,452 h80 r90
  text "GND" at 2252.04,435 h80 r90
  text "1 HS" at 4195.04,419 h80 r90
  text "OUT1_HS" at 4265,215.38 h70
  text "MCU_3V3" at 334.59,172 h40 r90
  text "MCU_STATUS" at 662.34,165 h40 r90
  text "GUI_STATUS" at 979.34,165 h40 r90
  text "DRV_STATUS" at 1133.34,165 h40 r90
  text "FAULT_STATUS" at 1308.34,165 h40 r90
  text ".Layer_Name" at 575,-2292.49 h55
Bottom Overlay:
  lines w10: 2110,1976 2260,1975 ; 2124.15,1574 2260,1574 ; 2136.15,1776 2260,1776 ; 3111,1632 3425,1632 3425,1781 3111,1781 3111,1632
  lines w20: 1874,2332 1951,2332 ; 2124.5,2332 2207.5,2332 ; 2595,1528 2595,1605 ; 2595,1778.5 2595,1861.5 ; 4506,2782.5 4506,2865.5 ; 4506,3039 4506,3116
  text "6D" at 2145.18,3131.25 h80
  text "VM" at 2361,3131.44 h80
  text "4S" at 2823.61,3130.59 h80
  text "4D" at 3019.91,3131.25 h80
  text "VM" at 3232,3131.44 h80
  text "2S" at 3731.5,3130.59 h80
  text "2D" at 3938.96,3131.25 h80
  text "VM" at 4149,3131.44 h80
  text "VM" at 4390,3131.08 h80
  text "GND" at 1784.11,3130.47 h80
  text "GND" at 2655.2,3130.47 h80
  text "GND" at 3554.16,3130.47 h80
  text "6S" at 1949.18,3126.12 h80
  text "GND" at 4478.96,2875 h80 r270
  text "GND" at 2115,2307.96 h80
  text "nSCS" at 2092,2062 h40
  text "SCLK" at 2092,1954 h40
  text "VIN" at 3931.34,1875.89 h80
  text "SDI" at 2092,1858 h40
  text "GND" at 230,1819.96 h80
  text "VIN" at 4530,1765 h80
  text "SDO" at 2092,1755 h40
  text "PUSH" at 1192.91,1696.9 h25
  text "RST" at 1448.76,1694.38 h25
  text "nSLEEP" at 2089,1661 h40
  text "GND" at 2564.96,1617 h80 r270
  text "GND" at 3946,1560.96 h80
  text "IN1" at 2092,1554 h40
  text "3V3" at 215,1535.96 h80
  text "GND" at 4530,1501.96 h80
  text "IN0" at 2092,1455 h40
  text "GND" at 4465,1160.96 h80
  text "OUT0_HS" at 4540,807.13 h80
  text "GND" at 4338,595.96 h80
  text "OUT1_HS" at 4540,291.13 h80
  text "7S" at 2060.08,91.6 h80
  text "GND" at 2297.77,91.62 h80
  text "VM" at 1673,90.66 h80
  text "7D" at 1863.06,90.66 h80
  text "5D" at 2766.57,89.19 h80
  text "5S" at 2968.56,89.19 h80
  text "GND" at 3206.8,89.21 h80
  text "3D" at 3684.07,89.08 h80
  text "3S" at 3888.64,89.08 h80
  text "GND" at 4122.34,89.1 h80
  text "VM" at 2592,88.25 h80
  text "VM" at 3491.57,88.13 h80
  text ".Layer_Name" at 575,-2292.49 h55
Top Paste:
  text ".Layer_Name" at 575,-2292.49 h25
Bottom Paste:
  text ".Layer_Name" at 575,-2292.49 h25
Top Solder:
  text ".Layer_Name" at 575,-2292.49 h55
  text ".Layer_Name" at 575,-2292.49 h55
Bottom Solder:
  text ".Layer_Name" at 575,-2292.49 h55
Drill Guide:
  text ".Layer_Name" at 575,-2292.49 h55
M1 Board Outline:
  lines w10: 4571,3150 ccw(c4471,3150) 4471,3250 100,3250 ccw(c100,3150) 0,3150 0,100 ccw(c100,100) 100,0 4471,0 ccw(c4471,100) 4571,100 4571,3154.25
  text ".Layer_Name" at 575,-2292.49 h55
M2 Board Dimensions:
  rectangle: -2,-1709 123,-1584
  rectangle: 123,-1834 498,-1709
  lines w7: -2,-1709 998,-1709 ; 123,-1834 123,-1584 ; 248,-1834 248,-1584 ; 498,-1834 498,-1584 ; 748,-1834 748,-1584 ; -2,-1834 998,-1834 998,-1584 -2,-1584 -2,-1834
  text ".Layer_Name" at 575,-2292.49 h55
M3 3D STEP Top:
  text ".Layer_Name" at 575,-2292.49 h25
M4 3D STEP Bottom:
  text ".Layer_Name" at 575,-2292.49 h25
M5 Assembly Top:
  lines w10: -294,-2364.17 6306,-2364.17 ; -294,-2160.83 6308,-2160.83 ; -294,-1957.5 -294,-2567.5 3711,-2567.5 6308,-2567.5 6308,-1957.5 -293.5,-1957.5 -293.5,-2567.5 1282,-2567.5 ; 2171,-2567.5 2171,-1957.5 ; 3438,-2160.83 3438,-1957.5 ; 4278,-2160.83 4278,-1957.5 ; 4900,-2574 4900,-2371.17
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 1151.5,-1752.5 h25
  text "ASSEMBLY VARIANT:" at 1151,-1868 h25
  text ".VariantName" at 2187,-1868 h25
  text "PCB VIEWED FROM TOP SIDE" at -230.5,-2089.67 h25
  text "BOARD #:" at 2246,-2089.67 h25
  text ".PRJ_Number" at 2791.5,-2089.67 h25
  text "REV:" at 3636,-2089.67 h25
  text ".PCB_Rev" at 3927.5,-2089.67 h25
  text "SVN REV:" at 4474,-2089.67 h25
  text ".VersionControl_RevNumber" at 4980,-2089.67 h25
  text "TID #:" at 2246,-2293 h25
  text ".TID" at 2791.5,-2293 h25
  text "PLOT NAME =" at -230.5,-2498.34 h25
  text ".plot_File_Name" at 575,-2498.34 h25
  text "GENERATED    :" at 2248,-2498.34 h25
  text ".Print_Date" at 3117.5,-2498.34 h25
  text ".Print_Time" at 3846.5,-2498.34 h25
  text "TEXAS INSTRUMENTS" at 5111,-2498.34 h25
M6 Assembly Bottom:
  lines w10: -294.5,-2161.33 6307.5,-2161.33 ; -292.5,-2364.67 6307.5,-2364.67 ; 1113.5,-2574.5 1113.5,-2371.67 ; 1735.5,-2161.33 1735.5,-1958 ; 2575.5,-2161.33 2575.5,-1958 ; 3842.5,-2568 3842.5,-1958 ; 4731.5,-2568 6307,-2568 6307,-1958 -294.5,-1958 -294.5,-2568 2302.5,-2568 6307.5,-2568 6307.5,-1958
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 6100,-1752 h25
  text ".VariantName" at 5056,-1868 h25
  text "ASSEMBLY VARIANT:" at 6095,-1868 h25
  text ".VersionControl_RevNumber" at 1033.5,-2090.17 h25
  text "SVN REV:" at 1539.5,-2090.17 h25
  text ".PCB_Rev" at 2086,-2090.17 h25
  text "REV:" at 2377.5,-2090.17 h25
  text ".PRJ_Number" at 3222,-2090.17 h25
  text "BOARD #:" at 3767.5,-2090.17 h25
  text "PCB VIEWED FROM BOTTOM SIDE" at 6244,-2090.17 h25
  text ".TID" at 3222,-2293.5 h25
  text "TID #:" at 3767.5,-2293.5 h25
  text "TEXAS INSTRUMENTS" at 902.5,-2498.84 h25
  text ".Print_Time" at 2167,-2498.84 h25
  text ".Print_Date" at 2896,-2498.84 h25
  text "GENERATED    :" at 3765.5,-2498.84 h25
  text ".plot_File_Name" at 5438.5,-2498.84 h25
  text "PLOT NAME =" at 6244,-2498.84 h25
M9 Title Sheet:
  drawing of 57 lines, arcs and shapes, not listed
  text "1" at 737.84,6602.5 h25
  text "2" at 3233.5,6602.5 h25
  text "3" at 5722.84,6602.5 h25
  text "4" at 8229.51,6602.5 h25
  text "5" at 10728.5,6602.5 h25
  text "6" at 13233.5,6602.5 h25
  text "A" at -418.5,5459.5 h25
  text "A" at 14381.5,5459.5 h25
  text "B" at -418.5,3079.5 h25
  text "B" at 14381.5,3079.5 h55
  text "C" at -418.5,704.5 h25
  text "C" at 14381.5,704.5 h55
  text "PROJECT TITLE:" at 11341.5,-1156.5 h55
  text "DRV81602Q1_EVM" at 11391.5,-1289.83 h55
  text "DESIGNED FOR:" at 11341.5,-1457.5 h55
  text ".PRJ_Customer" at 11391.5,-1597.5 h55
  text "D" at -418.5,-1665.5 h25
  text "D" at 14381.5,-1665.5 h55
  text "FILE NAME:" at 11341.5,-1757.5 h55
  text ".PCB_File_Name_No_Path" at 11391.5,-1877.5 h55
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 6372,-2039.34 h40
  text "ENGINEER:" at 11341.5,-2047.5 h55
  text "LAYOUT BY:" at 12846.5,-2047.5 h55
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 6327.01,-2152 h40
  text ".PRJ_Engineer" at 11391.5,-2202.49 h55
  text ".PCB_Layout" at 12897,-2202.49 h55
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 6327.01,-2264.67 h40
  text ".Layer_Name" at 575,-2292.49 h55
  text "ALTIUM DESIGNER VERSION:" at 12846.5,-2357.5 h55
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 6327.01,-2377.33 h40
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 6372,-2490 h40
  text ".print_Scale" at 11391.5,-2490.83 h55
  text ".Application_BuildNumber" at 12897,-2490.83 h55
  text "1" at 737.84,-2697.5 h25
  text "2" at 3233.5,-2697.5 h25
  text "3" at 5722.84,-2697.5 h25
  text "4" at 8229.51,-2697.5 h25
  text "5" at 10728.5,-2697.5 h25
  text "6" at 13233.5,-2697.5 h55
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 12380.02,4922.17 h55
  text "MIN. TRACK WIDTH:" at 11735.46,4790.05 h55
  text "6" at 12831.7,4790.05 h55
  text "MIL" at 12986.46,4790.05 h55
  text "5" at 12830,4671 h55
  text "MIN. CLEARANCE:" at 11735.46,4665.92 h55
  text "MIL" at 12986.46,4665.92 h55
  text "MIN. VIA PAD SIZE:" at 11735.46,4541.8 h55
  text "16" at 12801.71,4541.8 h55
  text "MIL" at 12986.46,4541.8 h55
  text "0.05mm (2MIL)" at 12430.46,4411.9 h55
  text "MINIMUM ANNULAR RING" at 11406.23,4403.67 h55
  text "EXTERNAL" at 13138.46,4403.67 h55
  text "PER" at 11606.23,4293.55 h55
  text "IPC-D-275 CLASS 2 LEVEL C" at 11826.23,4293.54 h55
  text "MIL, HOLES" at 13314.46,4193.07 h55
  text "+/-" at 12922,4184.48 h55
  text "+/-" at 13776,4184.48 h55
  text "REGISTRATION TOLERANCES:" at 11406.23,4183.42 h55
  text "METAL" at 12606,4183.42 h55
  text "5" at 13182.2,4183.42 h55
  text "3" at 14015.2,4183.42 h55
  text "MIL" at 14131.46,4183.42 h55
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 11406.23,4085.1 h55
  text "+/-" at 13776,4082.23 h55
  text "3" at 14015.2,4081.17 h55
  text "MIL" at 14131.46,4081.17 h55
  text "MATERIAL:" at 11331.46,3943.52 h55
  text "FR-4 High Tg" at 12317.9,3815 h55
  text "X" at 12173.46,3807.01 h55
  text "FR-408" at 11752.46,3802.49 h55
  text "OTHER" at 13240.46,3802.49 h55
  text "62 MIL (1.6mm) +/-10%" at 12072.56,3659.46 h55
  text "X" at 11952.46,3657.01 h55
  text "THICKNESS:" at 11406.23,3651.24 h55
  text "OTHER" at 13357.46,3651.24 h55
  text "TOLERANCE:" at 11406.23,3512.92 h55
  text "X" at 12254.46,3512.92 h55
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12432.48,3512.92 h55
  text "OTHER +/-" at 12432.46,3368.73 h55
  text "BOW & TWIST:" at 11406.23,3223.54 h55
  text "X" at 12254.46,3223.54 h55
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12432.48,3223.54 h55
  text "OTHER +/-" at 12432.46,3076.85 h55
  text "DRILLING:" at 11331.46,2946.23 h55
  text "NC_DRILL FILES" at 13092.46,2841.04 h55
  text "REFERENCE:" at 11406.23,2837.1 h55
  text "X" at 12063.46,2837.01 h55
  text "AS SHOWN" at 12241.46,2837.1 h55
  text "X" at 12964.46,2837.1 h55
  text "OTHER" at 13390.46,2694.85 h55
  text "PTH COPPER THICKNESS:" at 11405.91,2691.32 h55
  text "X" at 12545.14,2691.32 h55
  text "20-30 um" at 12673.14,2691.32 h55
  text "BOARD FINISH:" at 11331.46,2543.73 h55
  text "SILKSCREEN:" at 11486.68,2433.6 h55
  text "X" at 12444.46,2433.6 h55
  text "TOP" at 12561.46,2433.6 h55
  text "X" at 12954.46,2433.6 h55
  text "BOTTOM" at 13072.46,2433.6 h55
  text "SILKSCREEN COLOR:" at 11486.68,2278.41 h55
  text "X" at 12443.46,2278.41 h55
  text "WHITE" at 12561.46,2278.41 h55
  text "OTHER" at 13072.46,2278.41 h55
  text "X" at 12574.46,2134.96 h55
  text "GREEN" at 12692.46,2134.96 h55
  text "OTHER" at 13310.46,2134.96 h55
  text "SOLDER RESIST COLOR:" at 11486.68,2128.1 h55
  text "X" at 12574.46,1980.71 h55
  text "MATTE" at 12692.46,1980.71 h55
  text "SEMI-GLOSS" at 13310,1980.07 h55
  text "IMMERSION GOLD (ENIG)" at 12392.46,1807.94 h55
  text "ENEPIG" at 13730,1800.72 h55
  text "SURFACE FINISH:" at 11331.46,1799.72 h55
  text "X" at 12214.46,1799.72 h55
  text "IMM. TIN/SILVER OR EQUIV" at 11661,1662.4 h55
  text "OTHER" at 13092.46,1658.47 h55
  text "ARRAY/PANEL:" at 11331.46,1503.09 h55
  text "X" at 12214.46,1498.9 h55
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 12392.46,1494.87 h55
  text "N.C. ROUTE" at 12392.46,1358.9 h55
  text "V. SCORE" at 13258.46,1358.9 h55
  text "CERTIFICATION:" at 11331.46,1229.77 h55
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 12056.46,1229.77 h55
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 12056.46,1135.71 h55
  text "X" at 11693.97,1007.08 h55
  text "ANSI IPC-A-600F CLASS ->" at 11821.96,1007.08 h55
  text "X" at 13469.97,1007.08 h55
  text "2" at 13579.96,1007.08 h55
  text "1" at 13264.96,1005.58 h55
  text "3" at 13933.96,1005.58 h55
  text "X" at 12505.97,859.39 h55
  text "RoHS" at 12633.96,859.39 h55
  text "OTHER" at 13278.36,859.39 h55
  text "PER ORDER" at 13675.42,859.39 h55
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 11359,705.57 h55
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 11359,589.5 h55
  text "FAB NOTES:" at 5659.93,468.41 h55
  text "ADDITIONAL REQUIREMENTS:" at 11331.46,420.08 h55
  text "1. NO VENDOR LOGO OR NAME ON THE BOARD." at 5658.93,341.72 h55
  text "MICROSECTION:" at 11406.23,312.95 h55
  text "YES" at 12311.96,312.95 h55
  text "2. ALL HOLES SHOULD BE FHS." at 5658.93,219.09 h55
  text "REQUIRED" at 13173.46,168.62 h55
  text "BARE BOARD ELEC. TEST:" at 11406.23,165.76 h55
  text "NONE" at 12711.96,165.76 h55
  text "X" at 13055.46,165.76 h55
  text "PER ORDER" at 13765.46,165.76 h55
  text "3. CLIP SILK ON NO MASK AREA." at 5662.93,98.89 h55
  text "4. 7.87MIL DRILLS NEED TO BE NON-CONDUCTIVE SOLDER MASK PLUGGING FROM BOTTOM SIDE" at 5661,11 h55
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 11574.38,-39.18 h55
  text "5.REMOVE NON-FUNCTINAL PADS IN INNER LAYER ." at 5664,-85 h55
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 11582.38,-143.16 h55
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 11581.39,-306.54 h55
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 11573.39,-542.26 h55
  text ".Layer_Name" at 575,-2292.49 h55
M11 Gerber Information:
  circle w10: c-156,3367 r40
  circle w10: c-156,3367 r70
  circle w10: c4805,3309 r40
  circle w10: c4805,3309 r70
  circle w10: c4714,-106 r40
  circle w10: c4714,-106 r70
  lines w10: -294,-2364.17 6306,-2364.17 ; -294,-2160.83 6308,-2160.83 ; -294,-1957.5 -294,-2567.5 3711,-2567.5 6308,-2567.5 6308,-1957.5 -293.5,-1957.5 -293.5,-2567.5 1282,-2567.5 ; -256,3367 -56,3367 ; -156,3267 -156,3467 ; 2171,-2567.5 2171,-1957.5 ; 3438,-2160.83 3438,-1957.5 ; 4278,-2160.83 4278,-1957.5 ; 4614,-106 4814,-106 ; 4705,3309 4905,3309 ; 4714,-206 4714,-6 ; 4805,3209 4805,3409 ; 4900,-2574 4900,-2371.17
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -230.5,-2089.67 h55
  text "BOARD #:" at 2246,-2089.67 h55
  text "REV:" at 3636,-2089.67 h55
  text ".PCB_Rev" at 3927.5,-2089.67 h55
  text "SVN REV:" at 4474,-2089.67 h55
  text ".VersionControl_RevNumber" at 4980,-2089.67 h55
  text "DRV81602Q1_EVM" at 2672,-2101 h55
  text "LAYER NAME =" at -230.5,-2292.49 h55
  text "TID #:" at 2246,-2293 h55
  text ".TID" at 2791.5,-2293 h55
  text "PLOT NAME =" at -230.5,-2498.34 h55
  text ".plot_File_Name" at 575,-2498.34 h35
  text "GENERATED    :" at 2248,-2498.34 h55
  text ".Print_Date" at 3117.5,-2498.34 h55
  text ".Print_Time" at 3846.5,-2498.34 h55
  text "TEXAS INSTRUMENTS" at 5111,-2498.34 h55
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Stackup;" at 5701,3649.99 h60
  text "Layer" at 5741.98,3533.59 h51.05
  text "Name" at 6093.76,3533.59 h51.05
  text "Material" at 6896.37,3533.59 h51.05
  text "Thickness" at 7630.93,3533.59 h51.05
  text "Constant" at 8186.86,3533.59 h51.05
  text "Board Layer Stack" at 8674.74,3533.59 h51.05
  text "Top Overlay" at 6093.76,3431.48 h51.05
  text "Top Solder" at 6093.76,3329.37 h51.05
  text "Solder Resist" at 6896.37,3329.37 h51.05
  text "0.40mil" at 7630.93,3329.37 h51.05
  text "3.5" at 8186.86,3329.37 h51.05
  text "1" at 5741.98,3227.26 h51.05
  text "Top Layer" at 6093.76,3227.26 h51.05
  text "2.80mil" at 7630.93,3227.26 h51.05
  text "Dielectric 1" at 6093.76,3125.15 h51.05
  text "FR-4 High Tg" at 6896.37,3125.15 h51.05
  text "11.40mil" at 7630.93,3125.15 h51.05
  text "4.2" at 8186.86,3125.15 h51.05
  text "2" at 5741.98,3023.05 h51.05
  text "Signal Layer 1" at 6093.76,3023.05 h51.05
  text "1.40mil" at 7630.93,3023.05 h51.05
  text "Dielectric 2" at 6093.76,2920.94 h51.05
  text "FR-4 High Tg" at 6896.37,2920.94 h51.05
  text "30.00mil" at 7630.93,2920.94 h51.05
  text "4.2" at 8186.86,2920.94 h51.05
  text "3" at 5741.98,2818.83 h51.05
  text "Signal Layer 2" at 6093.76,2818.83 h51.05
  text "1.40mil" at 7630.93,2818.83 h51.05
  text "Dielectric 3" at 6093.76,2716.72 h51.05
  text "FR-4 High Tg" at 6896.37,2716.72 h51.05
  text "11.40mil" at 7630.93,2716.72 h51.05
  text "4.2" at 8186.86,2716.72 h51.05
  text "4" at 5741.98,2614.61 h51.05
  text "Bottom Layer" at 6093.76,2614.61 h51.05
  text "2.80mil" at 7630.93,2614.61 h51.05
  text "Bottom Solder" at 6093.76,2512.5 h51.05
  text "Solder Resist" at 6896.37,2512.5 h51.05
  text "0.40mil" at 7630.93,2512.5 h51.05
  text "3.5" at 8186.86,2512.5 h51.05
  text "Bottom Overlay" at 6093.76,2410.39 h51.05
  text ".Layer_Name" at 575,-2292.49 h55
M13 Component Bodies Top:
  text ".Layer_Name" at 575,-2292.49 h25
M14 Component Bodies Bottom:
  text ".Layer_Name" at 575,-2292.49 h25
M15 Courtyards Top:
  text ".Layer_Name" at 575,-2292.49 h25
M16 Courtyards Bottom:
  text ".Layer_Name" at 575,-2292.49 h25
Drill Drawing:
  circle w8: c5462.85,2000.82 r12.69
  circle w8: c5462.85,2000.82 r21.15
  circle w8: c5462.85,1525 r21.15
  lines w8: 5441.7,1313.52 5484,1313.52 5484,1355.82 5441.7,1355.82 5441.7,1313.52 ; 5441.7,1419.26 5452.28,1419.26 5462.85,1408.69 5473.43,1419.26 5484,1419.26 5473.43,1429.84 5484,1440.41 5473.43,1440.41 5462.85,1450.98 5452.28,1440.41 5441.7,1440.41 5452.28,1429.84 5441.7,1419.26 ; 5441.7,1641.31 5484,1641.31 5462.85,1599.02 5441.7,1641.31 ; 5441.7,1715.33 5462.85,1694.18 5484,1715.33 5462.85,1736.47 5441.7,1715.33 ; 5441.7,1789.34 5484,1789.34 5484,1831.64 5441.7,1831.64 5441.7,1789.34 ; 5441.7,1895.08 5452.28,1895.08 5452.28,1884.51 5473.43,1884.51 5473.43,1895.08 5484,1895.08 5484,1916.23 5473.43,1916.23 5473.43,1926.8 5452.28,1926.8 5452.28,1916.23 5441.7,1916.23 5441.7,1895.08 ; 5450.16,1321.98 5475.54,1321.98 5475.54,1347.36 5450.16,1347.36 5450.16,1321.98
  lines w12: 5403.25,1284.98 11066.39,1284.98 ; 5403.25,2046.28 11066.39,2046.28 ; 5758.04,1189.81 5758.04,2141.45 ; 6168,1189.81 6168,2141.45 ; 7026.98,1189.81 7026.98,2141.45 ; 7353.22,1189.81 7353.22,2141.45 ; 7824.06,1189.81 7824.06,2141.45 ; 8778.72,1189.81 8778.72,2141.45 ; 9470.27,1189.81 9470.27,2141.45 ; 10336.87,1189.81 10336.87,2141.45 ; 5403.25,1189.81 11066.39,1189.81 11066.39,2141.45 5403.25,2141.45 5403.25,1189.81
  text "Drill Drawing :" at 5418,2185.99 h60
  text "Symbol" at 5460.35,2074.83 h45.68
  text "Quantity" at 5786.59,2074.83 h45.68
  text "Finished Hole Size" at 6196.55,2074.83 h45.68
  text "Plated" at 7055.53,2074.83 h45.68
  text "Hole Type" at 7381.77,2074.83 h45.68
  text "Drill Layer Pair" at 7852.61,2074.83 h45.68
  text "Hole Tolerance" at 8807.27,2074.83 h45.68
  text "Routed Path Length" at 9498.82,2074.83 h45.68
  text "Hole Length" at 10365.42,2074.83 h45.68
  text "39" at 5786.59,1979.67 h38.07
  text "7.87mil (0.200mm)" at 6196.55,1979.67 h38.07
  text "PTH" at 7055.53,1979.67 h38.07
  text "Round" at 7381.77,1979.67 h38.07
  text "Top Layer - Bottom Layer" at 7852.61,1979.67 h38.07
  text "+3mil/-3mil" at 8807.27,1979.67 h38.07
  text "-" at 9498.82,1979.67 h38.07
  text "-" at 10365.42,1979.67 h38.07
  text "460" at 5786.59,1884.51 h38.07
  text "12.00mil (0.305mm)" at 6196.55,1884.51 h38.07
  text "PTH" at 7055.53,1884.51 h38.07
  text "Round" at 7381.77,1884.51 h38.07
  text "Top Layer - Bottom Layer" at 7852.61,1884.51 h38.07
  text "-" at 9498.82,1884.51 h38.07
  text "-" at 10365.42,1884.51 h38.07
  text "2" at 5786.59,1789.34 h38.07
  text "29.53mil (0.750mm)" at 6196.55,1789.34 h38.07
  text "PTH" at 7055.53,1789.34 h38.07
  text "Round" at 7381.77,1789.34 h38.07
  text "Top Layer - Bottom Layer" at 7852.61,1789.34 h38.07
  text "-" at 9498.82,1789.34 h38.07
  text "-" at 10365.42,1789.34 h38.07
  text "39" at 5786.59,1694.18 h38.07
  text "40.00mil (1.016mm)" at 6196.55,1694.18 h38.07
  text "PTH" at 7055.53,1694.18 h38.07
  text "Round" at 7381.77,1694.18 h38.07
  text "Top Layer - Bottom Layer" at 7852.61,1694.18 h38.07
  text "+3mil/-3mil" at 8807.27,1694.18 h38.07
  text "-" at 9498.82,1694.18 h38.07
  text "-" at 10365.42,1694.18 h38.07
  text "6" at 5786.59,1599.02 h38.07
  text "45.28mil (1.150mm)" at 6196.55,1599.02 h38.07
  text "PTH" at 7055.53,1599.02 h38.07
  text "Round" at 7381.77,1599.02 h38.07
  text "Top Layer - Bottom Layer" at 7852.61,1599.02 h38.07
  text "+3mil/-3mil" at 8807.27,1599.02 h38.07
  text "-" at 9498.82,1599.02 h38.07
  text "-" at 10365.42,1599.02 h38.07
  text "34" at 5786.59,1503.85 h38.07
  text "51.18mil (1.300mm)" at 6196.55,1503.85 h38.07
  text "PTH" at 7055.53,1503.85 h38.07
  text "Round" at 7381.77,1503.85 h38.07
  text "Top Layer - Bottom Layer" at 7852.61,1503.85 h38.07
  text "+3mil/-3mil" at 8807.27,1503.85 h38.07
  text "-" at 9498.82,1503.85 h38.07
  text "-" at 10365.42,1503.85 h38.07
  text "23" at 5786.59,1408.69 h38.07
  text "63.00mil (1.600mm)" at 6196.55,1408.69 h38.07
  text "PTH" at 7055.53,1408.69 h38.07
  text "Round" at 7381.77,1408.69 h38.07
  text "Top Layer - Bottom Layer" at 7852.61,1408.69 h38.07
  text "+3mil/-3mil" at 8807.27,1408.69 h38.07
  text "-" at 9498.82,1408.69 h38.07
  text "-" at 10365.42,1408.69 h38.07
  text "2" at 5786.59,1313.52 h38.07
  text "51.18mil (1.300mm)" at 6196.55,1313.52 h38.07
  text "PTH" at 7055.53,1313.52 h38.07
  text "Slot" at 7381.77,1313.52 h38.07
  text "Top Layer - Bottom Layer" at 7852.61,1313.52 h38.07
  text "+3mil/-3mil" at 8807.27,1313.52 h38.07
  text "-21.65mil (-0.550mm)" at 9498.82,1313.52 h38.07
  text "29.53mil (0.750mm)" at 10365.42,1313.52 h38.07
  text "605 Total" at 5786.59,1218.36 h38.07
  text "Slot definitions :" at 5460.35,1123.07 h38.07
  text "Routed Path Length" at 6120.15,1123.07 h38.07
  text "= Calculated from tool start centre position to tool end centre position." at 6824.35,1123.07 h38.07
  text "Hole Length" at 6120.15,1056.34 h38.07
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 6564.32,1056.34 h38.07
  text ".Layer_Name" at 575,-2292.49 h55
Mechanical 17:
  text ".Layer_Name" at 575,-2292.49 h55
Mechanical 18:
  text ".Layer_Name" at 575,-2292.49 h55
Mechanical 19:
  text ".Layer_Name" at 575,-2292.49 h55

## Dimensions
-2,-1834 to 998,-1834 on M2 Board Dimensions
5.08,3250 to 0,0 on M2 Board Dimensions
5.08,3250 to 4571,3154.25 on M2 Board Dimensions