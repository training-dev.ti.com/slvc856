# Altium PCB DRV81620Q1_EVM.PcbDoc (part 3 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4571 x 3250 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 263 components, 134 nets, 711 pads, 499 vias.
Unrouted connection lines stored in the file: 1.

## Part data (continued)
R18 R19 R57: library part CMP-0026935-3, "RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-47KJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=47k0, ValueDisplayed=47k
R30 R31 R32 R39 R40 R41 R51 R52 R53 R54 R98: library part CMP-0025886-5, "RES, 10 k, 5%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-10KGRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10k
R43: library part CMP-0082533-1, "RES, 4.99 k, 1%, 0.1 W, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-3985-1-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=4k99, ValueDisplayed=4.99k
R45 R47 R48 R49 R80 R81 R82 R83 R84 R85 R86 R87 R88: library part CMP-0025785-4, "RES, 330, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, PartNumber=CRCW0603330RJNEA, Power_W=100mW, Supplier Part Number 1=541-330GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=330R, ValueDisplayed=330
R55 R60: library part CMP-0026728-1, "RES, 220 k, 1%, 0.0625 W, 0402", Manufacturer="Yageo America", Power_W=62.5mW, Supplier Part Number 1=311-220KLRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.0625W, Value_Code=220k
R56: library part CMP-0026190-2, "RES, 240 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-240KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=240k
R58 R59: library part CMP-0025924-5, "RES, 470, 5%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-470GRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=470R, ValueDisplayed=470
R61: library part CMP-0026021-3, "RES, 150 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-150KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=150k
R72 R75: library part CMP-0026888-3, "RES, 27, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-27JCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=27R0, ValueDisplayed=27
R76: library part CMP-0026085-3, "RES, 1.40 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.40KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=1k40, ValueDisplayed=1.40k
R77: library part CMP-0026859-2, "RES, 1.0 M, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.0MJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=1M00, ValueDisplayed=1.0M
R78: library part CMP-0026907-3, "RES, 33 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-33KJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=33k0, ValueDisplayed=33k
R90 R91 R92 R93: library part CMP-0026736-1, "RES, 470, 1%, 0.063 W, 0402", Manufacturer="Yageo America", Power_W=63mW, Supplier Part Number 1=311-470LRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=470R, ValueDisplayed=470
R94 R95 R96: library part CMP-0026631-1, "RES, 4.70 k, 1%, 0.063 W, 0402", Manufacturer="TE Connectivity", Power_W=63mW, Supplier Part Number 1=A121542CT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=4k70, ValueDisplayed=4.70k
R97: library part CMP-0023620-3, "RES, 91.0 k, 0.1%, 0.1 W, 0603", Manufacturer="Susumu Co Ltd", Power_W=100mW, Supplier Part Number 1=RG16P91.0KBCT-ND, TempCo="25 ppm/C", Tolerance_%=0.1%, Value2=0.1W, Value_Code=91k0, ValueDisplayed=91.0k
S1: library part CMP-0097347-1, "Tactile Switch SPST-NO Top Actuated Surface Mount", Coil Resistance_ohm=100mΩ, Contact Current Rating=50mA, Digikey Part Number=732-7022-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-430481025816, Operating Force=160gf, Operating Temperature Range="-40°C to +85°C"
SH-J1 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J31 SH-J32 SH-J33 SH-J34 SH-J35 SH-J36: library part CMP-0003761-2, "Shunt, 2.54mm, Gold, Black", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-2678-ND
TP1 TP4 TP6 TP35: library part CMP-0055148-2, "Test Point, Multipurpose, Black, TH", Color=Black, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5011-ND
TP2 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 TP40 TP41: library part CMP-0055147-2, "Test Point, Multipurpose, Red, TH", Color=Red, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5010-ND
TP3 TP5: library part CMP-0055149-2, "Test Point, Multipurpose, White, TH", Color=White, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5012-ND
TP19 TP29 TP30 TP31 TP32 TP33 TP34: library part CMP-0003719-1, "Testpoint", Manufacturer="Texas Instruments"
TP22 TP23 TP24 TP25 TP26 TP27 TP28: library part CMP-0055139-2, "Test Point, Miniature, White, TH", Color=White, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5002-ND
TP36: library part CMP-0055140-2, "Test Point, Miniature, Orange, TH", Color=Orange, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5003-ND
TP37 TP38 TP39: library part CMP-0075110-1, "1mm Uninsulated Shorting Plug, 10.16mm spacing, TH", Manufacturer=Harwin, PartNumber=D3082-05, Supplier Part Number 1=952-1873-ND
U1: library part CMP-0038879-1, "20 MHz Mixed Signal Microcontroller with 256 KB Flash, 18432 B SRAM and 74 GPIOs, -40 to 85 degC, 100-pin QFP (PZ), Green (RoHS & no Sb/Br)", Frequency(MHz)=20, Manufacturer="Texas Instruments", Temp Sensor=Yes
U2: library part CMP-0039269-4, "16-Bit Ultra-Low-Power Microcontroller, 128KB Flash, 8KB RAM, USB, 12Bit ADC, 2 USCIs, 32Bit HW MPY, RGC0064B (VQFN-64)", Alternate Manufacturer="Texas Instruments", Alternate PartNumber=MSP430F5528IRGCR, Frequency(MHz)=25, Operating Temperature Range="-40 to 85 C", Rating=Catalog, Temp Sensor=Yes
U3: library part CMP-0036328-3, "500mA, Adjustable, Low Quiescent Current, Low-Noise, High-PSRR, Single-Output LDO Regulator, DRB0008A (VSON-8)", Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 125 C", Rating=Catalog
U4: library part CMP-0070570-1, "Ultra-Low Quiescent Current Voltage Regulator, 8-pin Narrow SOIC, Pb-Free", Manufacturer="Texas Instruments", PackageTopMarking=NSZXTT*LM903*6M-3, PowerWise=N
U5: library part CMP-0120421-1, "8-channel Configurable Low-side and High-side Driver for Automotive Relay, Lighting and Motor Control", Manufacturer="Texas Instruments", Max Supply Voltage=40V, Min Supply Voltage=3V, Operating Temperature Range="-40°C to +150°C"
U6: library part CMP-0043099-3, "Low-Capacitance 2-Channel +/-15kV ESD Protection Array for High-Speed Data Interfaces, DRY0006A (USON-6)", Breakdown Voltage(Min)(V)=11, IO Capacitance(Typ)(pF)=1.5, IO Leakage Current(nA)=1, Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 85 C", Rating=Catalog
U7: library part CMP-0013424-7, "33-V Precision Surge Protection Clamp, DRV0006A (WSON-6)", Manufacturer="Texas Instruments"
Y1: library part CMP-0085483-1, "Oscillator, 4 MHz, 700 ppm, 39 pF, SMD", Frequency_Fixed=4MHz, Frequency Tolerance="700 ppm", Load Capacitance="39 pF", Manufacturer=MuRata
Y2: library part CMP-0004566-4, "Crystal, 32.768 kHz, 12.5pF, SMD", Frequency Tolerance="20 ppm", Frequency_Fixed=32.768kHz, Load Capacitance="12.5 pF", Manufacturer="Micro Crystal AG", Supplier Part Number 1=94M8466
ZZ1: library part CMP-0003616-3
ZZ2: library part CMP-0077236-1
ZZ3: library part CMP-0077237-1
ZZ4: library part CMP-0077238-1

## Via types
v1: diameter 24, hole 12, Top Layer to Bottom Layer, tented both sides, 268 vias
v2: diameter 26, hole 12, Top Layer to Bottom Layer, tented both sides, 192 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 37 vias
v4: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
CHANNEL_0: D15.2 U1.50 | length 1555.4
  Top Layer w8: v1@959.38,651.06 U1.50@959.38,703.87 ; D15.2@2183.27,1129.56 2183.74,1129.09 v1(2223.61,1129.09)
  Bottom Layer w8: v1(959.7,650.73) 1301.23,992.26 2033.77,992.26 2141.58,1100.07 2194.58,1100.07 v1(2223.61,1129.09)
CHANNEL_1: D19.2 U1.51 | length 1238.3
  Top Layer w8: U1.51@1027.29,771.78 1247.54,771.78 v1(1278,741.32) ; v1(2154.6,848.1) 2173.49,848.1 D19.2@2183.27,857.88
  Bottom Layer w8: v1(1278,741.32) 1302.68,766 2056,766 2076.39,786.39 2129.39,786.39 2154.6,811.6 v1(2154.6,848.1)
CHANNEL_2: D14.2 U1.52 | length 1351.2
  Top Layer w8: U1.52@1027.29,791.46 1292.85,791.46 1319.94,764.38 1319.94,747.06 v1(1323,744) ; D14.2@2019.86,1129.12 v1(2088.61,1129.09)
  Signal Layer 2 w8: v1(1323,744) 1323.89,744.89 1323.89,768 1420.2,864.32 1564.92,864.32 1787.93,1087.33 1817.33,1087.33 1881.09,1151.09 2066.61,1151.09 v1(2088.61,1129.09)
CHANNEL_3: D18.2 U1.53 | length 1046.7
  Top Layer w8: U1.53@1027.29,811.15 1328.85,811.15 1351,789 1374,789 v1(1375,788)
  Bottom Layer w8: v1(1375,788) 1991,788 2023,820 v1(2023,848.1)
CHANNEL_4: D13.2 U1.54 | length 1133.4
  Top Layer w8: U1.54@1027.29,830.83 1333.08,831.24 1338.36,836.52 1437.52,836.52 v1(1439,838) ; D13.2@1860.45,1129.84 1860.73,1130.12 1947.59,1130.12 v1(1948.61,1129.09)
  Signal Layer 2 w8: v1(1439,838) 1596,838 1831.33,1073.33 1846.72,1073.33 1874.5,1101.1 1920.61,1101.1 v1(1948.61,1129.09)
CHANNEL_5: D17.2 U1.55 | length 1009.3
  Top Layer w8: U1.55@1027.29,850.52 1392.2,850.52 v1(1428,886.32) ; D17.2@1860.45,858.16 1870.49,848.12 v1(1900.99,848.12)
  Bottom Layer w8: v1(1428,886.32) 1546.17,886.32 1618.85,959 1732.96,959 1811.81,880.16 1868.95,880.16 v1(1900.99,848.12)
CHANNEL_6: D12.2 U1.56 | length 910.6
  Top Layer w8: U1.56@1027.29,870.2 1336.89,870.2 v1(1378,911.32) ; D12.2@1712.25,1129.81 1712.56,1130.12 1755.34,1130.12 1763.05,1137.83 v1(1767.38,1137.83)
  Signal Layer 2 w8: v1(1378,911.32) 1542.83,911.32 1767.38,1135.87 v1(1767.38,1137.83)
CHANNEL_7: D16.2 U1.57 | length 793.3
  Top Layer w8: U1.57@1027.29,889.89 1224,889.89 1228,893.89 1250.89,893.89 v1(1252,895) ; D16.2@1712.25,858.13 1714.22,858.13 1737.66,881.57 1737.66,891.18 v1(1740.72,894.24)
  Bottom Layer w8: v1(1252,895) 1287,860 1578.84,860 1587.84,869 1715.48,869 v1(1740.72,894.24)
DRV_STATUS: D11.2 U1.35 | length 691.5
  Top Layer w8: v1@664.1,651.06 U1.35@664.1,703.87
  Top Layer w10: D11.2@1188.94,465.34 v1(1188.94,528.04)
  Bottom Layer w8: v1(663.78,650.73) 703.51,611 877,611 909,579 1137.98,579 v1(1188.94,528.04)
EZFET_AVBUS: C24.2 R56.1 R61.2 U2.1 | length 558.2
  Top Layer w10: 335,2455 335,2403.38 U2.1@353.81,2384.57
  Top Layer w12: 335,2455 v1(389.23,2509.23)
  Top Layer w20: v1(400,2770) R61.2@368.62,2770 R56.1@368.62,2720 C24.2@425.32,2720
  Signal Layer 1 w12: v1(389.23,2509.23) 389.23,2755.99 400,2766.75 v1(400,2770)
EZFET_AVCC2ADC: C22.2 R55.1 R60.2 U2.2 | length 412.1
  Top Layer w10: 344.73,2365.19 345.03,2364.89 360.34,2364.89 U2.2@360.62,2364.61
  Top Layer w12: 344.73,2365.19 315.13,2394.79 315.13,2477.74 368.62,2531.24 R60.2@368.62,2620
  Top Layer w20: R60.2@368.62,2620 R55.1@368.62,2670 C22.2@425.32,2670
EZFET_D_N: C42.1 R72.2 U2.52 | length 644.6
  Top Layer w10: U2.52@622.43,2409.89 622.7,2410.16 622.7,2424.06 634.48,2435.84 645.57,2435.84 679.73,2470 1106.5,2470 1135,2498.5 1135,2512.65 1129.14,2518.5 1124.84,2518.5 1120,2523.35 R72.2@1120,2525.31 1073.94,2525.31 C42.1@1070,2521.38
EZFET_D_P: C43.1 R75.2 R76.1 R77.2 U2.50 | length 720.9
  Top Layer w10: U2.50@661.8,2409.89 661.8,2423.78 688.02,2450 820.42,2450 ; R76.1@820,2404.69 820,2441.5 820.42,2441.91 820.42,2450 ; R77.2@895,2404.69 895,2441.5 895.14,2441.63 895.14,2450 ; C43.1@1220,2521.38 1216.06,2525.31 R75.2@1170,2525.31 1170,2523.35 1165.16,2518.5 1160.86,2518.5 1155,2512.65 1155,2490.22 1114.78,2450 895.14,2450 ; 820.42,2450 895.14,2450
EZFET_LED0: R58.1 U2.20 | length 122.7
  Top Layer w10: R58.1@371,1971.5 371,1972.48 444.99,2046.47 444.99,2063.15 U2.20@445.26,2063.43
EZFET_LED1: R59.1 U2.21 | length 107.2
  Top Layer w10: R59.1@446,1971.5 446,1972.48 473.84,2000.32 473.84,2024.16 464.95,2033.06 U2.21@464.95,2063.43
EZFET_PUR: R76.2 U2.51 | length 222.7
  Top Layer w10: v1(640,2370) 640,2397 641.84,2398.84 641.84,2409.61 U2.51@642.11,2409.89
  Top Layer w12: v1(790,2370) 792.3,2367.7 817.61,2367.7 R76.2@820,2365.31
  Signal Layer 2 w12: v1(640,2370) v1(790,2370)
EZFET_RST: C23.2 J9.11 R57.1 U2.64 | length 1139.3
  Top Layer w8: v1(365,2440) 365,2438.18 386.21,2416.97 U2.64@386.21,2409.89
  Top Layer w12: J9.11@310,3157 v1(310,3055.83) 368.62,2997.21 R57.1@368.62,2820 C23.2@415.47,2820
  Signal Layer 1 w12: v1@316.92,3062.75 257.07,3002.9 257.07,2879.52 309.89,2826.7 309.89,2495.11 v1(365,2440)
EZFET_TCK: J9.7 U2.63 | length 937.6
  Top Layer w8: v1(405,2375) 405.45,2375.45 405.45,2409.44 U2.63@405.89,2409.89
  Top Layer w12: v1(509,3076) 509,3156 J9.7@510,3157
  Signal Layer 1 w12: v1(405,2375) 405,2428.41 399.13,2434.28 399.13,2442.47 357.07,2484.52 357.07,2981.6 391.52,3016.05 449.05,3016.05 v1(509,3076) v1@511.42,3078.42
EZFET_TDI: J9.3 U2.61 | length 926.8
  Top Layer w8: v1(445,2375) 445.13,2375.13 445.13,2409.76 U2.61@445.26,2409.89
  Top Layer w10: v1(703.43,3062.4) 703.43,3150.43 J9.3@710,3157
  Bottom Layer w10: v1(445,2375) 445,2429.82 449.87,2434.7 449.87,2604.87 648.78,2803.78 648.78,3007.76 v1(703.43,3062.4)
EZFET_TDO: J9.1 U2.60 | length 899.2
  Top Layer w8: U2.60@464.95,2409.89 464.95,2432.92 475,2442.97 v1(475,2445)
  Top Layer w10: v1(803.43,3062.4) 803.43,3150.43 J9.1@810,3157
  Bottom Layer w10: v1(475,2445) 475,2448.79 471.13,2452.66 471.13,2586.13 605.13,2720.13 605.13,2730.3 619.7,2744.87 629.87,2744.87 748.78,2863.78 748.78,3007.76 v1(803.43,3062.4)
EZFET_TEST: J9.8 U2.59 | length 619.9
  Top Layer w8: v1@484.63,2375.37 484.82,2375.55 484.82,2409.7 U2.59@484.63,2409.89
  Top Layer w15: v1(506.43,2861.57) 508.15,2863.3 508.15,2942.55 J9.8@510,2944.4
  Signal Layer 1 w15: v1(485,2375) 485,2377.44 513,2405.44 513,2855 v1(506.43,2861.57)
EZFET_TMS: J9.5 U2.62 | length 862.4
  Top Layer w8: v1(425,2445) 425.29,2444.71 425.29,2410.18 U2.62@425.58,2409.89
  Top Layer w12: v1(609,3069) 609,3156 J9.5@610,3157
  Signal Layer 1 w12: v1(425,2445) 450,2470 450,2974.53 491.52,3016.05 557.07,3016.05 609,3067.98 v1(609,3069)
EZFET_UARTRXD: R66.1 U2.38 | length 331.3
  Top Layer w10: R66.1@671,1932.72 673.87,1935.59 675.84,1935.59 692.57,1952.32 698.32,1952.32 v1(701,1955) ; U2.38@707.07,2187.45 738.89,2187.45 746.34,2180 v1(750.13,2180)
  Signal Layer 1 w10: v1(701,1955) 701,2098.83 700.33,2099.5 700.33,2130.2 v1(750.13,2180)
EZFET_UARTTXD: R67.1 U2.37 | length 303.3
  Top Layer w10: R67.1@596,1932.72 598.87,1935.59 600.84,1935.59 617.57,1952.32 623.32,1952.32 v1(626,1955) ; v1(675,2165) 677.49,2167.49 706.8,2167.49 U2.37@707.07,2167.76
  Signal Layer 1 w10: v1(626,1955) 626,2084.08 625.32,2084.75 625.32,2115.32 v1(675,2165)
EZFET_USB_Shield: C47.1 J11.6 J11.7 J11.8 J11.9 J11.10 J11.11 R78.2
  other v1: 955,3031 1337,3031.41 955.15,3069.75 1337.15,3070.16
EZFET_V18: C28.1 U2.55 | length 158.3
  Top Layer w10: U2.55@563.37,2409.89 563.65,2410.16 563.65,2424.06 638.41,2498.82 656.3,2498.82 670,2512.52 C28.1@670,2513.5
EZFET_VBUS: C20.2 C21.1 C35.1 C36.1 C37.1 C48.2 L1.2 R56.2 U2.53 U3.5 U3.8 U6.1 | length 2287.9
  Top Layer w8: v1(600,2370) 602.02,2372.02 602.02,2409.16 U2.53@602.74,2409.89
  Top Layer w12: U3.8@931.61,2775.12 931.61,2799.88 938.64,2806.91 1008.39,2806.91
  Top Layer w15: C48.2@820,2788.5 827.87,2780.63 873.52,2780.63 879.04,2775.12 U3.8@931.61,2775.12 ; U3.5@1008.39,2775.12 1008.39,2806.91 1014.31,2812.84 1014.31,2828.8 1025.51,2840 C37.1@1026.5,2840 1029.77,2843.28 1068.28,2843.28 v1(1070,2845) 1105.25,2845 1114.04,2853.79 U6.1@1114.04,2860
  Top Layer w20: v1(282.94,2720) R56.2@321.38,2720 ; C35.1@595,2796.38 595,2755 v1(630,2720) 630.77,2720.77 664.27,2720.77 C36.1@670,2726.5 ; C20.2@1295,2695 1298.25,2698.25 1298.25,2766.75 1295,2770 1295,2846.93 ; L1.2@1297.56,2895 1295,2892.44 1295,2846.93 ; v1(1320,2845) 1319.23,2845.77 1296.16,2845.77 1295,2846.93
  Signal Layer 1 w15: v1(600,2370) 600,2690 v1(630,2720)
  Signal Layer 2 w20: v1(282.94,2720) v1(630,2720) 787.5,2720 912.5,2845 v1(1070,2845) v1(1320,2845)
EZFET_VCC: C31.2 C32.1 C33.1 C34.1 J10.9 R55.2 R57.2 R62.2 R63.2 R68.1 U2.11 U2.15 U2.40 | length 3223.2
  Top Layer w10: C32.1@226.5,2170 236.5,2160 v1(310,2160) ; U2.15@360.62,2108.71 333.81,2108.71 310,2132.51 v1(310,2160) ; U2.11@360.62,2187.45 360.34,2187.17 337.17,2187.17 v1(310,2160) ; U2.40@707.07,2226.82 772.63,2226.82
  Top Layer w15: R62.2@670,2792.44 R63.2@745,2792.44 C33.1@745,2726.5 746.97,2724.53 818.03,2724.53 R68.1@820,2722.56 ; 772.63,2226.82 780.45,2219 825.14,2219 C31.2@849.13,2195
  Top Layer w20: v1(250,2670) R55.2@321.38,2670 ; v1(280,2820) R57.2@321.38,2820 ; C34.1@521,1908.5 521,1858.82 546.4,1833.42 J10.9@546.4,1783.62 ; R63.2@745,2792.44 750.75,2798.19 751.73,2798.19 762.78,2809.23 779.23,2809.23 v1(780,2810) ; v1(810,2135) 810,2173.5 831.5,2195 C31.2@849.13,2195
  Top Layer w25: v1(498,1776) 534.4,1776 J10.9@541,1782.6
  Signal Layer 1 w20: v1(280,2820) 250,2790 250,2220 v1(310,2160) 310,2158.92 336,2132.92 336,2068 498,1906 v1(498,1776)
  Signal Layer 2 w20: v1(280,2820) 768.92,2820 778.92,2810 v1(780,2810) ; v1(310,2160) 354.87,2115.13 789.04,2115.13 808.92,2135 v1(810,2135)
EZFET_Vcore: C29.2 U2.17 | length 174.8
  Top Layer w12: 329.79,2063.43 U2.17@386.21,2063.43
  Top Layer w15: C29.2@224.53,2095 298.22,2095 329.79,2063.43
EZFET_VREF: C25.1 U2.9 | length 141.7
  Top Layer w12: C25.1@226.5,2245 239.2,2232.3 294.75,2232.3 300.24,2226.82 U2.9@360.62,2226.82
EZFET_VUSB: C30.1 U2.54 | length 293.9
  Top Layer w10: v1(560,2370) 582.78,2392.78 582.78,2409.61 U2.54@583.06,2409.89 ; v1(709.23,2509.23) 740.73,2509.23 C30.1@745,2513.5
  Bottom Layer w10: v1(560,2370) 696.56,2506.56 706.56,2506.56 v1(709.23,2509.23)
EZFET_XT2IN: U2.57 Y1.1 | length 146.9
  Top Layer w10: U2.57@524,2409.89 524,2436.7 572.81,2485.51 576.54,2485.51 579.41,2488.38 Y1.1@579.41,2531.69
EZFET_XT2OUT: U2.58 Y1.3 | length 142.8
  Top Layer w10: Y1.3@461.3,2531.69 461.3,2488.38 464.17,2485.51 469.67,2485.51 504.32,2450.86 U2.58@504.32,2409.89
FAULT_STATUS: D3.2 U1.36 | length 1005.6
  Top Layer w8: v1(1333,626) 1353,606 D3.2@1353,467.34
  Top Layer w10: v1@668.95,799.05 683.79,784.22 U1.36@683.79,703.87
  Signal Layer 2 w10: v1(668.95,802.84) 1069.16,802.84 1246,626 v1(1333,626)
GND: C1.1 C2.1 C3.2 C4.2 C5.2 C6.2 C7.2 C8.1 C9.2 C10.2 C11.1 C12.2 C13.1 C14.1 C15.2 C16.2 C17.2 C18.2 C19.2 C20.1 C21.2 C22.1 C23.1 C24.1 C25.2 C26.1 C27.1 C28.2 C29.1 C30.2 C31.1 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.1 C42.2 C43.2 C44.2 C45.2 C46.1 C47.2 C48.1 C49.1 C50.2 C51.1 C52.2 C53.2 C54.2 C55.1 C56.1 C57.2 C58.2 C59.1 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 D1.1 D2.1 D20.2 J4.4 J5.4 J7.1 J7.2 J8.1 J9.9 J10.11 J10.12 J12.2 J13.2 J16.2 J17.2 J18.4 J19.4 J22.2 J23.2 J24.4 J25.4 J28.2 J29.2 L2.2 R30.2 R32.2 R43.1 R45.1 R47.1 R48.1 R49.1 R51.2 R52.2 R53.2 R60.1 R61.1 R77.1 R78.1 R80.1 R81.1 R82.1 R83.1 R84.1 R85.1 R86.1 R87.1 R88.1 R98.2 S1.3 S1.4 TP1.1 TP4.1 TP6.1 TP35.1 TP37.1 TP37.2 TP38.1 TP38.2 TP39.1 TP39.2 U1.10 U1.12 U1.15 U1.26 U1.29 U1.63 U1.76 U1.83 U1.90 U2.14 U2.16 U2.39 U2.49 U2.56 U2.65 U3.4 U3.9 U4.2 U4.3 U4.4 U4.5 U4.6 U4.7 U5.5 U5.25 U6.4 U7.1 U7.2 U7.3 U7.7@3569.52,1389.72 Y1.2 Y2.3 | length 2204.1
  Top Layer w8: v1(188,946) 234.38,946 C44.2@239.38,941 ; v1(975.19,1008) U1.63@1027.29,1008 ; v1(1490,3020) 1492,3022 1492,3088 v1(1494,3090) ; U5.25@3368,1671 3377.37,1680.37 C9.2@3483,1680.37
  Top Layer w10: U2.16@360.62,2089.02 360.89,2089.3 374.79,2089.3 412.32,2126.83 412.32,2142.32 v1(415,2145) ; U2.14@360.62,2128.39 394.6,2128.39 v1@411.21,2145 ; U1.15@419.02,968.63 419.37,968.98 448.88,968.98 485.6,1005.69 485.6,1028.6 v1(488,1031) ; U1.12@419.02,1027.69 480.9,1027.69 484.21,1031 v1(488,1031) ; U1.10@419.02,1067.06 475.27,1067.06 476.53,1068.32 477.1,1068.32 478.71,1066.71 v1(483,1071) ; C49.1@453.41,626.9 486.94,660.43 U1.26@486.94,703.87 487.28,704.21 487.28,733.72 506.88,753.32 515.32,753.32 v1(518,756) 520.68,753.32 526.05,753.32 545.65,733.72 545.65,704.21 U1.29@545.99,703.87 ; v1@478.25,1065.75 485.32,1058.68 485.32,1033.68 v1(488,1031) ; U2.65@533.84,2236.66 535.13,2237.94 535.13,2380.3 543.69,2388.86 U2.56@543.69,2409.89 ; v1(607.08,1381.31) 607.08,1385.1 614.3,1392.32 614.3,1400.8 C54.2@628,1414.5 628,1409.13 642.62,1394.51 643.61,1394.51 683.79,1354.33 U1.90@683.79,1312.13 ; v1(640,2210) 642.87,2207.13 U2.39@707.07,2207.13 ; U2.49@681.48,2409.89 U2.49@681.48,2409.89 709.94,2409.94 v1(710,2410) ; U1.83@821.58,1312.13 821.58,1266.21 833,1254.79 v1(833,1251) ; U1.76@959.38,1312.13 959.38,1311.84 960.21,1311 v1(988,1311) ; U3.4@1008.39,2664.88 1008.39,2670.59 1009.49,2671.69 1022.9,2671.69 1026.21,2675 v1(1030,2675) ; U6.4@1155,2883.62 1155,2885.59 1161.51,2892.1 1161.51,2897.24 v1(1164.19,2899.92)
  Top Layer w12: C40.2@895,2568.62 901.89,2568.62 943.32,2527.19 964.19,2527.19 C39.2@970,2521.38
  Top Layer w14: 1573,1974 1597.53,1949.47 C59.1@1597.53,1910 ; C41.1@1597.53,1736 1597.76,1735.76 1597.76,1706.24 v1(1598,1706) ; v3(3220.76,1706) v3(3268,1706) ; U5.5@3306.39,1820.17 3306.39,1762.1 v3(3315.24,1753.24) v3(3268,1706) ; v3(3315.24,1658.76) v3(3268,1706) ; v2(3356,1082) v2@3356,1085.25 ; v2(3506,932) v2@3506,935.25
  Top Layer w20: v1(2257.44,857.19) 2258.2,857.95 2258.2,883.76 R88.1@2261.56,887.11 ; R43.1@3384.7,2167.21 3389.97,2167.19 3395.72,2161.44 3395.72,2153.09 3396.23,2152.58 3396.23,2134.77 v1(3397,2134) ; C3.2@3993.03,2123.3 3993.51,2122.81 3993.51,2091.49 v1(3994,2091) ; C5.2@4070,2120.72 4073.51,2124.23 4101.23,2124.23 v1(4102,2125) ; C11.1@4150,2120.72 4150.14,2120.86 4184.86,2120.86 v1(4185,2121) ; C12.2@4230,2122.69 4231.23,2121.46 4231.23,2092.77 v1(4232,2092)
  Signal Layer 1 w15: v1@1035,2337.56 v1(1035,2340)
  other v1: 2524.45,58.82 3435.04,64.53 4495.16,217.91 712,222 1228,251 1073,256 1403,256 263,506 270,708 148,761 3449.01,779 2899.01,804 153,861 3049.01,861.17 3349.01,911.17 3449.01,911.17 3049,990 3349.01,1011.17 3027,1039 663,1086 203,1126 3056,1156 4012,1231 4203.01,1271.17 4153.01,1321.17 4253.01,1321.17 178,1326 358,1626 358,1726 1901.95,1731.78 891,1855 728,1866 628,1876 3463,1931 1905,1937 556,1970 856,1970 1581,1995 1091,1996 1279,2001 566,2015 150,2060 150,2125 990,2150 1080,2195 150,2205 3030,2239 990,2240 2636,2240 4468,2276 4351,2292 420,2310 650,2310 4217,2413 99,2477 196,2477 1020,2520 4377,2548 710,2570 422,2614 1070,2615 1220,2615 710,2620 895,2620 482.63,2690 889.23,2719.23 1235,2730 1065,2755 280,2770 480,2770 555,2850 920,2895 1379,2911 870,2920 1475,2930 1527,2971 1410,3090
  other v2: 56,182 506,182 656,182 806,182 956,182 1106,182 1256,182 1406,182 1706,182 2156,182 2306,182 4256,182 56,332 506,332 806,332 956,332 1106,332 1256,332 1556,332 1706,332 2156,332 2306,332 2456,332 3056,332 3206,332 3956,332 4106,332 56,482 506,482 956,482 1106,482 1256,482 1556,482 2306,482 2456,482 3206,482 4106,482 56,632 1106,632 1406,632 1556,632 1706,632 2306,632 2456,632 2606,632 3056,632 3206,632 3506,632 3656,632 3956,632 4256,632 56,782 2456,782 3056,782 4256,782 4406,782 56,932 506,932 656,932 1106,932 2456,932 2606,932 2906,932 3656,932 3806,932 4106,932 56,1082 2456,1082 2606,1082 2906,1082 3656,1082 3806,1082 3956,1082 4106,1082 4256,1082 56,1232 1706,1232 1856,1232 2006,1232 3956,1232 4106,1232 4256,1232 56,1382 356,1382 506,1382 1706,1382 2156,1382 2306,1382 3506,1382 3956,1382 4106,1382 4256,1382 56,1532 206,1532 356,1532 2456,1532 4106,1532 56,1682 206,1682 356,1682 506,1682 656,1682 806,1682 1106,1682 2456,1682 2606,1682 2756,1682 2906,1682 3056,1682 56,1832 206,1832 356,1832 2456,1832 2606,1832 2756,1832 2906,1832 3506,1832 56,1982 1406,1982 2606,1982 56,2132 1106,2132 1256,2132 1406,2132 1556,2132 1706,2132 2306,2132 3356,2132 3506,2132 3956,2132 56,2282 956,2282 1106,2282 1256,2282 1406,2282 1556,2282 1706,2282 2006,2282 2156,2282 2306,2282 3656,2282 4256,2282 56,2432 1256,2432 1406,2432 1556,2432 1706,2432 56,2582 206,2582 1256,2582 1406,2582 1556,2582 2006,2582 2456,2582 2606,2582 4406,2582 206,2732 1406,2732 1556,2732 2006,2732 2306,2732 2456,2732 2906,2732 3206,2732 3356,2732 3806,2732 4256,2732 4406,2732 56,2882 1406,2882 1556,2882 1856,2882 2006,2882 2156,2882 2456,2882 2606,2882 2906,2882 3056,2882 3356,2882 3656,2882 3806,2882 4256,2882 4406,2882 56,3032 1556,3032 2006,3032 2456,3032 3056,3032 3356,3032 3806,3032
  other v3: 3126.27,1658.76 3173.51,1658.76 3220.76,1658.76 3268,1658.76 3362.49,1658.76 3409.73,1658.76 3126.27,1706 3173.51,1706 3315.24,1706 3362.49,1706 3409.73,1706 3126.27,1753.24 3173.51,1753.24 3220.76,1753.24 3268,1753.24 3362.49,1753.24 3409.73,1753.24 506.48,2162.84 561.21,2162.84 460.03,2209.3 506.48,2209.3 561.21,2209.3 607.66,2209.3 460.03,2264.02 506.48,2264.02 561.21,2264.02 607.66,2264.02 506.48,2310.48 561.21,2310.48 970,2700.31 945.39,2720 994.61,2720 970,2739.69
  other v4: 3569.52,1368.07 3569.52,1411.37
GUI_STATUS: D10.2 U1.34 | length 709.4
  Top Layer w8: U1.34@644.42,703.87 v1@644.42,756.68
  Top Layer w10: D10.2@1030.04,465.34 v1(1030.04,528.04)
  Bottom Layer w10: v1(644.74,757) 614,726.26 614,637 676,575 859,575 905.96,528.04 v1(1030.04,528.04)
ID0: R39.2 R51.1 U1.43 | length 1036.3
  Top Layer w8: v1(798,770) 821.58,746.42 U1.43@821.58,703.87 ; v1(1093,1486) 1095.69,1486 1105.69,1476 1163,1476 ; R51.1@1163,1453.56 R39.2@1163,1498.44
  Bottom Layer w8: v1(798,770) 798,982.34 1096.87,1281.21 1096.87,1482.13 v1(1093,1486)
ID1: R40.2 R52.1 U1.44 | length 1132.3
  Top Layer w8: v1@841.27,651.06 U1.44@841.27,703.87 ; v1(1208,1476) 1246.48,1476 1250.2,1472.28 ; R52.1@1250.2,1448.56 1250.2,1472.28 ; R40.2@1250.2,1496 1250.2,1472.28
  Bottom Layer w8: v1(841.59,650.73) 837.13,655.19 837.13,657.31 828,666.44 828,986.68 1208,1366.68 v1(1208,1476)
ID2: R41.2 R53.1 U1.45 | length 1038.8
  Top Layer w8: U1.45@860.95,703.87 v1@860.95,756.68 ; v1(1293,1476) 1332.47,1476 1333,1475.47 ; R53.1@1333,1451.75 1333,1475.47 ; R41.2@1333,1499.19 1333,1475.47
  Bottom Layer w8: v1(860.63,757) 860.38,757.24 860.38,996.61 1293,1429.23 v1(1293,1476)
ID3: R30.1 R54.2 U1.46 | length 1187.1
  Top Layer w8: v1@880.64,651.06 U1.46@880.64,703.87 ; v1(1373,1476) 1415.97,1476 1418,1473.97 ; R30.1@1418,1450.25 1418,1473.97 ; R54.2@1418,1497.69 1418,1473.97
  Bottom Layer w8: v1(880.96,650.73) 894,663.77 894,801 879.63,815.37 879.63,982.63 v1(1373,1476)
ID4: R31.2 R32.1 U1.47 | length 1156.9
  Top Layer w8: U1.47@900.32,703.87 900.32,743.32 v1(924,767) ; v1(1463,1476) 1510.56,1476 1513,1478.44 ; R32.1@1513,1456 1513,1478.44 ; R31.2@1513,1500.88 1513,1478.44
  Bottom Layer w8: v1(924,767) 924,812 895.5,840.5 895.5,963.5 1348,1416 1403,1416 v1(1463,1476)
IN0: J7.3 TP22.1 U5.23 | length 1614.9
  Top Layer w8: U5.23@3383.16,1593.6 3388.02,1588.74 3388.02,1558.84 3407.8,1539.06 3414.94,1539.06 v1(3418,1536)
  Top Layer w14: J7.3@2008,1476 TP22.1@2168,1476
  Signal Layer 2 w12: TP22.1@2168,1476 2298,1476 2408,1366 3269.67,1366 3415.7,1512.03 3415.7,1533.7 v1(3418,1536)
IN0_MCU: R94.2 U1.69 | length 441.2
  Top Layer w8: U1.69@1027.29,1126.11 1220.85,1126.11 1370.96,976 R94.2@1406.31,976
IN1: J7.5 TP23.1 U5.22 | length 1621
  Top Layer w8: U5.22@3357.78,1593.38 3357.78,1550.3 3373.15,1534.93 3380.81,1534.93 v1(3383.87,1531.87)
  Top Layer w14: J7.5@2008,1576 TP23.1@2278,1576
  Signal Layer 2 w12: TP23.1@2278,1576 2278.97,1575.03 2278.97,1525.03 2408,1396 3261.92,1396 3372,1506.08 3372,1516.75 3383.87,1528.63 v1(3383.87,1531.87)
IN1_MCU: R95.2 U1.70 | length 434.6
  Top Layer w8: U1.70@1027.29,1145.8 1240.65,1145.8 1360.45,1026 R95.2@1412.25,1026
MCU_3V3: C46.2 C50.1 C51.2 C52.1 C53.1 C54.1 D5.2 J1.3 J10.10 R9.2 R18.1 R19.2 R31.1 R37.1 R39.1 R40.1 R41.1 R54.1 TP36.1 U1.25 U1.64 U1.87 U1.89 | length 6938.8
  Top Layer w10: 207.25,1216 230.28,1239.03 R37.1@230.28,1241 R9.2@230.28,1291 ; 315.79,749.47 357.21,749.47 v1(359.34,747.34) 362.02,750.02 374.62,750.02 395.79,771.19 418.43,771.19 U1.25@419.02,771.78
  Top Layer w12: v1(958,1206) 958,1063.29 993.61,1027.69 U1.64@1027.29,1027.69
  Top Layer w14: v1(588,1576) 585.29,1576 579.98,1581.31 552.31,1581.31 J10.10@541,1570 553.69,1557.31 553.69,1508.69 561.89,1500.49 608.1,1500.49 616.3,1492.29 616.3,1489.2 C54.1@628,1477.5 661.22,1477.5 ; v1(687.23,1180.09) 689.15,1182 704,1182 742.84,1220.84 742.84,1332.9 742.06,1333.68 742.06,1350.66 733.86,1358.86 705.42,1358.86 702.41,1355.85 702.41,1342.88 702.69,1342.6 702.69,1312.91 U1.89@703.47,1312.13 ; 701.45,1358.86 701.45,1392.98 671.86,1422.57 671.86,1466.85 661.22,1477.5 ; R18.1@723,1464.62 723,1468.56 714.06,1477.5 661.22,1477.5
  Top Layer w15: TP36.1@147.5,1462.5 TP36.1@154,1469 TP36.1@166.81,1485.14 ; v1(173,1216) 207.25,1216 224.84,1198.41 246.1,1198.41 278.51,1166 C50.1@279.5,1166 ; C51.2@275.84,811.41 291.79,811.41 315.79,787.41 315.79,749.47 315.79,682.65 C53.1@326.52,671.92 C52.1@326.52,610.31 326.52,549.5 C46.2@326.79,549.23 ; C46.2@326.52,549.23 326.52,497.48 356.18,467.82 384.95,467.82 D5.2@389.87,462.9 ; D5.2@386.54,467.82 D5.2@394.79,467.82
  Top Layer w20: v1(1128,1581.15) 1155.6,1553.56 R39.1@1163,1553.56 ; v1(1213.42,1581.15) 1243.46,1551.12 R40.1@1250.2,1551.12 ; v1(1291.97,1581.15) 1318.82,1554.31 R41.1@1333,1554.31 ; v1(1381.68,1581.15) 1410.03,1552.81 R54.1@1418,1552.81 ; R31.1@1513,1556 1568,1611 v1(1568,1616) ; R19.2@1591.62,1809 1595.56,1809 1597.37,1810.81 1597.37,1814.75 1599.23,1816.61 1599.23,1850.23 v1(1600,1851)
  Top Layer w25: TP36.1@147.5,1462.5 147.5,1241.5 v1(173,1216)
  Top Layer w30: TP36.1@154,1469 TP36.1@156,1471
  Signal Layer 1 w14: v1(958,1206) 958,1366 1043,1451 1043,1496.15 1124.06,1577.21 v1@1128,1577.21 ; v1@1133,1577.21 v1@1133,1581
  Signal Layer 1 w20: v1(1568,1616) 1568,1819 v1(1600,1851)
  Signal Layer 2 w20: v1(173,1216) 174.08,1216 184.08,1206 418.99,1206 454.9,1170.09 676.15,1170.09 686.15,1180.09 v1(687.23,1180.09) ; v1(588,1576) 1120.41,1576 1125.41,1581 v1@1128,1581 ; v1(1568,1616) 1996.28,1616 2008,1604.28 2008,1331 2121,1218 2889,1218 J1.3@2997.52,1109.48
  Bottom Layer w10: v1(173,1216) 173,1154.72 165.11,1146.82 165.11,1089.33 382.87,871.56 382.87,770.87 v1(359.34,747.34)
  Bottom Layer w20: v1(1128,1581.15) v1(1213.42,1581.15) v1(1291.97,1581.15) v1(1381.68,1581.15) 1533.15,1581.15 v1(1568,1616)
MCU_STATUS: D8.2 TP19.1 U1.37 | length 349
  Top Layer w8: U1.37@703.47,703.87 703.47,656.53 712.26,647.74 D8.2@712.26,466.34 818.95,471.75 TP19.1@819.72,471.06
MCU_UARTRXD: J10.8 U1.61 | length 848.2
  Top Layer w8: v1(798,1195.79) 798,1151.15 980.52,968.63
  Top Layer w10: J10.8@630,1569.7 664.69,1569.7 685.74,1548.65 685.74,1518.73 708.98,1495.5 735.24,1495.5 764.74,1466 v1(798,1466) ; 980.52,968.63 U1.61@1027.29,968.63
  Signal Layer 1 w10: v1(798,1195.79) v1(798,1466)
MCU_UARTTXD: J10.6 U1.60 | length 811.6
  Top Layer w8: v1(798,1116) 965.02,948.96
  Top Layer w10: J10.6@741,1570 741,1550.69 755.69,1536 v1(788,1536) ; 965.02,948.96 U1.60@1027.28,948.96
  Signal Layer 1 w10: v1(788,1536) 768,1516 768,1146 v1(798,1116)
NetC15_1: C15.1 R9.1 U1.9 | length 365.8
  Top Layer w10: C15.1@279.5,1366 279.5,1306.75 265.72,1292.97 268.59,1290.09 268.59,1286.16 338,1216.75 338,1138.25 389.17,1087.09 418.68,1087.09 U1.9@419.02,1086.74
NetC26_2: C26.2 J10.1 R64.2 | length 211
  Top Layer w10: C26.2@896,1916.38 949.94,1916.38 966.16,1900.16 968.13,1900.16 R64.2@971,1897.28 ; J10.1@955,1775.02 955,1883.25 R64.2@969.03,1897.28
NetC27_2: C27.2 J10.3 R65.2 | length 236.7
  Top Layer w10: R65.2@746,1897.28 805.84,1897.28 C27.2@821,1912.44 ; C27.2@821,1916.38 C27.2@821,1912.44 ; J10.3@855,1775.02 821,1809.02 C27.2@821,1912.44
NetC38_1: C38.1 C40.1 R68.2 U3.1 | length 360.6
  Top Layer w12: R68.2@820,2667.44 820.98,2667.44 822.26,2666.16 820.81,2664.71 820.81,2633.69 855.34,2599.16 855.34,2513.5
  Top Layer w15: C38.1@820,2513.5 855.34,2513.5 890.69,2513.5 895,2517.81 C40.1@895,2521.38 ; R68.2@822.26,2666.16 930.33,2666.16 U3.1@931.61,2664.88
NetC39_1: C39.1 U3.3 | length 101.6
  Top Layer w12: C39.1@970,2568.62 970,2612.32 982.8,2625.12 U3.3@982.8,2664.88
NetC44_1: C44.1 U1.14 Y2.1 | length 180.7
  Top Layer w8: C44.1@286.62,941 286.62,977.32 306.54,997.23 Y2.1@347.8,997.23 356.72,988.32 U1.14@419.02,988.32
NetC45_1: C45.1 U1.13 Y2.2 | length 192.8
  Top Layer w10: C45.1@271.62,1091 271.62,1072.19 311.15,1032.66 Y2.2@347.8,1032.66 364.04,1032.66 388.36,1008.35 418.65,1008.35 U1.13@419.02,1008
NetC49_2: C49.2 U1.27 | length 79.4
  Top Layer w10: U1.27@506.62,703.87 506.97,703.52 506.97,632.4 C49.2@512.47,626.9
NetD1_2: D1.2 R58.2 | length 625.4
  Top Layer w10: v1(210,2380) 211.5,2380 D1.2@245,2413.5 ; v1(326,1900) 329.79,1900 338.29,1908.5 R58.2@371,1908.5
  Signal Layer 1 w10: v1(210,2380) 210,2016 v1(326,1900)
NetD2_2: D2.2 R59.2 | length 692.8
  Top Layer w10: D2.2@145,2413.5 v1@175,2383.5 ; v1(432.3,1881.3) 432.3,1893.82 R59.2@446,1907.52
  Bottom Layer w10: v1(175,2380) 175,2116 304.01,1986.99 326.61,1986.99 v1(432.3,1881.3)
NetD3_1: D3.1 R80.2 | length 71.1
  Top Layer w8: R80.2@1353,313.56 D3.1@1353,384.66
NetD5_1: D5.1 R49.2 | length 77.5
  Top Layer w25: R49.2@394.45,317.62 394.62,317.79 394.62,394.81 D5.1@394.79,394.98
NetD6_1: D6.1 R43.2 | length 71.5
  Top Layer w25: R43.2@3384.7,2222.33 D6.1@3384.72,2293.78
NetD8_1: D8.1 R45.2 | length 78.3
  Top Layer w25: R45.2@712.25,315.15 712.25,393.43 D8.1@712.29,393.47
NetD10_1: D10.1 R47.2 | length 78.3
  Top Layer w25: R47.2@1030.04,314.15 1030.04,392.43 D10.1@1030.08,392.47
NetD11_1: D11.1 R48.2 | length 78
  Top Layer w25: D11.1@1188.38,391.92 1188.93,391.37 R48.2@1188.93,314.15
NetD12_1: D12.1 R81.2 | length 78.4
  Top Layer w8: D12.1@1712.25,1047.13 1742.71,1047.15 1743,1047.44 R81.2@1789.31,1048.21 ; R81.2@1789.33,1047.03 R81.2@1789.33,1048.19
NetD13_1: D13.1 R82.2 | length 76.1
  Top Layer w8: D13.1@1860.45,1047.16 1860.86,1046.76 1935.93,1046.76 R82.2@1936.24,1047.06
NetD14_1: D14.1 R83.2 | length 84.6
  Top Layer w8: D14.1@2019.86,1046.45 2020.86,1047.44 2103.23,1047.44 R83.2@2103.81,1046.87
NetD15_1: D15.1 R84.2 | length 78.5
  Top Layer w8: D15.1@2183.27,1046.88 2183.4,1046.76 2212.99,1046.76 2213.46,1047.23 R84.2@2261.56,1047.23
NetD16_1: D16.1 R85.2 | length 77.9
  Top Layer w8: D16.1@1712.25,940.81 1712.63,940.43 1743.61,940.43 1787.74,940.43 R85.2@1789.33,942.03
NetD17_1: D17.1 R86.2 | length 76.6
  Top Layer w8: D17.1@1860.45,940.84 1860.86,940.43 1934.61,940.43 R86.2@1936.24,942.06
NetD18_1: D18.1 R87.2 | length 84.7
  Top Layer w8: D18.1@2019.86,940.12 2020.17,940.43 2102.37,940.43 R87.2@2103.81,941.87
NetD19_1: D19.1 R88.2 | length 79.1
  Top Layer w8: D19.1@2183.27,940.56 2183.4,940.43 2212.32,940.43 2214.12,942.23 R88.2@2261.56,942.23
NetJ1_2: J1.2 R1.2 | length 623
  Top Layer w20: v1(3468,1506) R1.2@3468,1536
  Signal Layer 2 w20: J1.2@2998,1209 3171,1209 v1(3468,1506)
NetJ6_2: J6.2 S1.1 S1.2 | length 477.3
  Top Layer w15: S1.2@1058.2,1842.26 S1.1@1321.98,1842.26 ; J6.2@1280,1657.91 1280,1800.28 S1.1@1321.98,1842.26 ; S1.1@1333.8,1842.26 S1.1@1321.98,1842.26
NetJ7_4: J7.4 R94.1 | length 686.6
  Top Layer w12: R94.1@1453,981 1460.56,981 1660.23,1180.67 1660.23,1418.23 1718,1476 J7.4@1795.4,1476
NetJ7_6: J7.6 R95.1 | length 719.9
  Top Layer w12: R95.1@1456.62,1026 1462.43,1031.81 1471.53,1031.81 1642.23,1202.51 1642.23,1464.17 1754.06,1576 J7.6@1795.4,1576
NetJ7_8: J7.8 R96.1 | length 801.1
  Top Layer w12: R96.1@1453,1066 1460.56,1066 1624.23,1229.67 1624.23,1534.3 1697.28,1607.34 1697.28,1654.49 1718.79,1676 J7.8@1795.4,1676
NetJ7_10: J7.10 R92.1 | length 852.5
  Top Layer w12: R92.1@1453,1116 1460.56,1116 1606.23,1261.67 1606.23,1541.75 1679.28,1614.8 1679.28,1738.9 1716.38,1776 J7.10@1795.4,1776
NetJ7_12: J7.12 R91.1 | length 886.1
  Top Layer w12: R91.1@1456.62,1161 1462.43,1166.81 1473.55,1166.81 1588.23,1281.5 1588.23,1549.21 1661.28,1622.25 1661.28,1783.21 1754.06,1876 J7.12@1795.4,1876
NetJ7_14: J7.14 R93.1 | length 967.9
  Top Layer w12: R93.1@1456.62,1201 1462.43,1206.81 1473.09,1206.81 1570.23,1303.95 1570.23,1556.66 1643.28,1629.71 1643.28,1902.9 1716.38,1976 J7.14@1795.4,1976
NetJ7_16: J7.16 R90.1 | length 1027.5
  Top Layer w12: R90.1@1453,1241 1460.56,1241 1552.23,1332.67 1552.23,1564.12 1625.28,1637.16 1625.28,1984.9 1716.38,2076 J7.16@1795.4,2076
NetJ9_2: J9.2 R63.1 | length 129.3
  Top Layer w15: R63.1@745,2847.56 745.98,2847.56 789.3,2890.88 797.81,2890.88 810,2903.06 J9.2@810,2944.4
NetJ9_4: J9.4 R62.1 | length 114
  Top Layer w15: R62.1@670,2847.56 670.98,2847.56 703.43,2880 703.43,2937.83 J9.4@710,2944.4
NetJ10_5: J10.5 R66.2 | length 157.1
  Top Layer w10: R66.2@671,1897.28 671,1859.02 J10.5@755,1775.02
NetJ10_7: J10.7 R67.2 | length 146.7
  Top Layer w10: R67.2@596,1897.28 596,1834.02 J10.7@655,1775.02
NetJ11_1: J11.1 L1.1 | length 174.8
  Top Layer w10: J11.1@1192.18,3049 1192.18,2986.83 1213.15,2965.87 1213.15,2925.28 1242.44,2895.98 L1.1@1242.44,2895
NetJ11_5: J11.5 L2.1 | length 203.8
  Top Layer w10: L2.1@1022.56,2895 1031.68,2904.12 1069.12,2904.12 1089.82,2924.82 J11.5@1089.82,3049
NetR3_1: R3.1 U4.8 | length 65.2
  Top Layer w20: U4.8@2889.57,2318.19 2889.57,2358.13 R3.1@2907.44,2376
NetR4_2: R4.2 U4.1 | length 63
  Top Layer w20: R4.2@2662.56,2376 2675,2363.56 U4.1@2675,2318.19
NetR37_2: R37.2 U1.11 | length 273.7
  Top Layer w12: R37.2@265.72,1241 265.72,1239.03 318,1186.75 318,1120.12 390.65,1047.46 418.93,1047.46 U1.11@419.02,1047.37
NetTP29_1: TP29.1 U1.42 | length 960.6
  Top Layer w10: v1(801,541) 801.84,541.84 801.84,703.8 U1.42@801.9,703.87
  Bottom Layer w10: TP29.1@162.13,158.43 418.42,158.43 v1(801,541)
NetTP30_1: TP30.1 U1.16 | length 779.5
  Top Layer w10: v1(368,948) 368.6,948.6 418.68,948.6 U1.16@419.02,948.94
  Signal Layer 1 w10: TP30.1@168.44,350.07 202.07,350.07 233,381 400,543.58 400,912.21 368,944.21 v1(368,948)
NetTP31_1: TP31.1 U1.88 | length 1660.3
  Top Layer w10: v1(708,1236) 708,1239.79 723.16,1254.95 U1.88@723.16,1312.13
  Signal Layer 1 w15: v1(116.64,1222.13) 116.64,330.71 168.44,267.94 TP31.1@170.4,265.57
  Signal Layer 2 w12: v1(116.64,1222.13) 119.57,1222.13 139.31,1241.87 672,1241.87 677.87,1236 v1(708,1236)
NetTP32_1: TP32.1 U1.19 | length 405.4
  Top Layer w10: v1(318,886) 321.79,886 325.68,889.89 U1.19@419.02,889.89
  Bottom Layer w10: TP32.1@168.28,645.56 168.27,651.18 168.41,651.18 168.11,651.48 168.11,736.11 v1(318,886)
NetTP33_1: TP33.1 U1.20 | length 456.7
  Top Layer w10: v1(348,856) 351.79,856 365.99,870.2 U1.20@419.02,870.2
  Bottom Layer w10: TP33.1@169.41,550.17 208.97,589.73 208.97,716.97 v1(348,856)
NetTP34_1: TP34.1 U1.21 | length 551.7
  Top Layer w10: v1(358,816) 358,819.01 389.17,850.17 418.68,850.17 U1.21@419.02,850.52
  Bottom Layer w10: TP34.1@168.44,432.19 224.97,488.72 224.97,703.97 337,816 v1(358,816)
nSCS: J7.15 TP28.1 U5.1 | length 1696.2
  Top Layer w12: U5.1@3408.37,1818.78 3408.37,1894.13 3417,1902.75 v1(3417,1906)
  Top Layer w14: J7.15@2008,2076 TP28.1@2168,2076
  Signal Layer 2 w12: TP28.1@2168,2076 2338,2076 2436,2174 3225.46,2174 3417,1982.46 v1(3417,1906)
nSCS_MCU: R90.2 U1.67 | length 452.7
  Top Layer w8: U1.67@1027.29,1086.74 v1(1087.26,1086.74) ; v1(1361.64,1248.31) 1364.7,1245.25 1379.38,1245.25 1383.63,1241 1407.6,1241 R90.2@1409.31,1239.29
  Bottom Layer w8: v1(1087.26,1086.74) 1248.83,1248.31 v1(1361.64,1248.31)
nSLEEP: J7.7 TP24.1 U5.21 | length 1643.6
  Top Layer w8: U5.21@3331.98,1593.6 3331.98,1543.92 3348,1527.89 v1(3348,1526)
  Top Layer w14: J7.7@2008,1676 TP24.1@2168,1676
  Signal Layer 2 w12: TP24.1@2168,1676 2288,1676 2358,1606 2358,1486 2428,1416 3247.98,1416 3327.54,1495.55 3327.54,1504.04 3348,1524.5 v1(3348,1526)
nSLEEP_MCU: R96.2 U1.71 | length 423.4
  Top Layer w8: U1.71@1027.29,1165.48 1254.7,1165.48 1354.18,1066 R96.2@1409.5,1066
OUT0_HS: C55.2 J12.1 TP3.1 U5.6 | length 2458.3
  Top Layer w15: U5.6@3280.8,1818.4 U5.6@3280.8,1820.17 v1(3280.8,1888.2)
  Top Layer w30: TP3.1@4037,865.36 TP3.1@4037,847 4052,862 4052,869 4062.91,879.91 4096.78,879.91 4098.07,881.2 4370.74,881.2 4375.74,886.2 4388.31,886.2 J12.1@4412.69,910.57
  Bottom Layer w30: v1(3280.8,1888.2) 3280.8,1947.8 3362,2029 3746,2029 3798,1977 3798,1757 4045,1510 4045,855 TP3.1@4037,847 ; C55.2@4325.66,887.95 4329.36,891.66 4393.77,891.66 J12.1@4412.69,910.57
OUT1_HS: C56.2 J13.1 TP5.1 U5.19 | length 2441.5
  Top Layer w15: 3280.8,1468.8 U5.19@3280.8,1591.83
  Top Layer w20: 3257,1445 3280.8,1468.8
  Top Layer w30: 3257,1445 3257,946.75 3391.75,812 3929.38,812 4061.72,679.66 4061.72,666.79 4065.42,663.09 4065.42,662.11 4086.74,640.79 4092.82,640.79 4181.34,552.27 4181.34,549.66 4309.43,421.57 J13.1@4410.69,421.57 4410.69,125.32 TP5.1@4413,123
  Bottom Layer w30: C56.2@4305.85,424.83 4307.48,423.2 4409.06,423.2 J13.1@4410.69,421.57
OUT2_D: C18.1 J5.2 J15.1 TP9.1 U5.7 | length 1951.1
  Top Layer w14: U5.7@3255.2,1820.17 3255.2,1995.8
  Top Layer w30: 3255.2,1995.8 3263,2003.59 3263,2433 3494,2664 3826,2664 3904.91,2742.91 4044.5,2742.91 J15.1@4054,2752.41 ; TP9.1@3894,2732 3885,2741 3885,3049 J5.2@3894,3058
  Bottom Layer w30: C18.1@3893.27,2980.02 3893.64,2980.39 3893.64,3057.64 J5.2@3894,3058
OUT2_S: C17.1 J5.3 J17.1 TP10.1 U5.8 | length 1694.4
  Top Layer w14: 3218.31,1973.69 3229.61,1962.39 U5.8@3229.61,1820.17
  Top Layer w30: 3218.31,1973.69 3218.31,2459.31 3492.52,2733.52 3513.52,2733.52 J17.1@3531,2751 3531,2895 J5.3@3694,3058 ; J17.1@3532,2750 3532.5,2750.5 3692.5,2750.5 TP10.1@3693,2750
  Bottom Layer w30: C17.1@3693.53,2977.07 3693.76,2977.3 3693.76,3057.76 J5.3@3694,3058
OUT3_D: C62.1 J19.2 J21.1 TP12.1 U5.18 | length 1798.9
  Top Layer w10: 3253.82,1478.59 3255.2,1477.2
  Top Layer w14: 3255.2,1477.2 U5.18@3255.2,1591.83
  Top Layer w20: 3217,1439 3217,1448.84 3244.16,1476 3251.23,1476 3253.82,1478.59
  Top Layer w30: 3217,1439 3217,889 3363,743 TP12.1@3590,743 3592,741 3592,492 J21.1@3594,490 3592,488 3592,378 3644,326 J19.2@3644,215
  Bottom Layer w30: J19.2@3644,215 3645.08,216.08 3645.08,300.89 C62.1@3646.16,301.97
OUT3_S: C61.1 J19.3 J23.1 TP14.1 U5.17 | length 2691.5
  Top Layer w10: 3203.19,1471.8 3205.04,1471.8 3229.61,1496.38
  Top Layer w14: 3229.61,1496.38 U5.17@3229.61,1591.83
  Top Layer w20: 3179.54,1439.23 3179.54,1448.15 3203.19,1471.8
  Top Layer w30: 3179.54,1439.23 3176,1435.7 3176,863 3352.34,686.66 3352.34,186.66 3424,115 3744,115 J19.3@3844,215 3843.5,215.5 3843.5,473.5 3858,488 3843.5,502.5 3843.5,607.02 3843,607.52 TP14.1@3843,742
  Bottom Layer w30: J19.3@3844,215 3845.07,216.07 3845.07,300.9 C61.1@3846.14,301.97
OUT4_D: C66.1 J25.2 J27.1 TP16.1 U5.9 | length 1672.7
  Top Layer w14: 3182.31,1966.46 3204.02,1944.74 U5.9@3204.02,1820.17
  Top Layer w30: J25.2@2977,3058 2978,3057 2978,2605 TP16.1@2979,2604 2791,2416 2791,2186 2892,2085 3067.91,2085 3182.31,1970.6 3182.31,1966.46
  Bottom Layer w30: C66.1@2975.66,2976.49 2976.33,2977.16 2976.33,3057.33 J25.2@2977,3058
OUT4_S: C65.1 J25.3 J29.1 TP18.1 U5.10 | length 1646.8
  Top Layer w14: 3159.93,1937.93 3164.07,1937.93 3180.84,1921.16 3180.84,1866.56 3178.43,1864.15 U5.10@3178.43,1820.17
  Top Layer w30: TP18.1@2720,2605 2720,2589.58 2744,2565.58 2744,2167 2867.43,2043.57 3058.43,2043.57 3109.18,1992.82 3109.18,1988.67 3159.93,1937.93 ; TP18.1@2721,2606.42 J29.1@2721,2760 2777,2816 J25.3@2777,3058
  Bottom Layer w30: C65.1@2776.72,2977.15 2776.86,2977.29 2776.86,3057.86 J25.3@2777,3058
OUT5_D: C57.1 J4.2 J14.1 TP7.1 U5.16 | length 1789
  Top Layer w14: 3204.02,1525 U5.16@3204.02,1591.83
  Top Layer w20: 3145.39,1456 3165.41,1476.02 3204.02,1514.63 3204.02,1525
  Top Layer w30: J4.2@2727,215 J14.1@2727,490 TP7.1@2727,736 2727,1252.49 2930.51,1456 3145.39,1456
  Bottom Layer w30: J4.2@2727,215 2728.58,216.58 2728.58,300.77 C57.1@2730.17,302.35
OUT5_S: C19.1 J4.3 J16.1 TP8.1 U5.15 | length 2809.1
  Top Layer w10: 3157.03,1504.41 3161.27,1504.41
  Top Layer w14: 3161.27,1504.41 3178.43,1521.57 U5.15@3178.43,1591.83
  Top Layer w20: 3137.27,1492 3144.62,1492 3157.03,1504.41
  Top Layer w30: TP8.1@2926,734 2926,569.12 2926.5,568.62 J16.1@2926.5,490.5 ; J16.1@2926.5,489.5 2926.5,215.5 J4.3@2927,215 2846,134 2687,134 2611,210 2611,362.5 2550,423.5 2550,698 2683,831 2683,1290 2885,1492 3137.27,1492
  Bottom Layer w30: C19.1@2926.21,302.35 2926.61,301.96 2926.61,215.39 J4.3@2927,215
OUT6_D: C60.1 J18.2 J20.1 TP11.1 U5.12 | length 3140.1
  Top Layer w20: 3085.17,1820.17 U5.12@3126.39,1820.02
  Top Layer w30: TP11.1@2106,2604 J20.1@2106,2760.34 J18.2@2106,3058 2033,3131 1879,3131 1676,2928 1676,2681.78 1971.35,2386.43 2293.57,2386.43 2716,1964 2941.35,1964 3085.17,1820.17
  Bottom Layer w30: C60.1@2104.6,2970.28 2105.3,2970.98 2105.3,3057.3 J18.2@2106,3058
OUT6_S: C58.1 J18.3 J22.1 TP13.1 U5.11 | length 2233.1
  Top Layer w14: U5.11@3152.84,1820.17 3152.84,1888.16
  Top Layer w20: 3123,1918 3152.84,1888.16
  Top Layer w30: J22.1@1844,2760 1906,2822 J18.3@1906,3058 ; J22.1@1845,2759 1844.5,2758.5 1844.5,2604.5 2011,2438 2307.69,2438 2745.69,2000 3041,2000 3123,1918
  Bottom Layer w30: C58.1@1904.39,2977 1905.2,2977.8 1905.2,3057.2 J18.3@1906,3058
OUT7_D: C64.1 J24.2 J26.1 TP15.1 U5.13 | length 2445.4
  Top Layer w20: 3088,1591 U5.13@3126.43,1591
  Top Layer w30: J24.2@1818,215 1810.53,222.47 1810.53,467.95 1807.48,471 1807.48,485.52 J26.1@1790,503 1800,503 1812,515 TP15.1@1812,653.43 1820.26,645.17 1941.61,645.17 1976.5,680.06 1976.5,689.5 2018,731 2227,731 2321,825 2321,1109 2474.81,1262.81 ; 2475.44,1263.44 2803,1591 3088,1591
  Bottom Layer w30: J24.2@1818,215 1818.18,215.18 1818.18,314.45 C64.1@1818.37,314.64
OUT7_S: C63.1 J24.3 J28.1 TP17.1 U5.14 | length 2259.7
  Top Layer w16: 3137.39,1528.61 3141,1525 3152.84,1536.84
  Top Layer w18: U5.14@3151.98,1591.68 3152.84,1536.84
  Top Layer w30: J24.3@2018,215 2023.47,220.47 2023.47,482.47 J28.1@2044,503 2030,517 2030,649 2046.55,665.55 2218.55,665.55 2374.79,821.79 2374.79,989.97 2371.09,993.67 ; 2370.66,993.67 2371.09,993.67 ; 3137.39,1528.61 2813.61,1528.61 2374.79,1089.79 2374.79,997.37 2371.09,993.67
  Bottom Layer w30: J24.3@2018,215 2018.66,215.66 2018.66,313.98 C63.1@2019.32,314.64
PUSH: J6.3 U1.38 | length 1145.3
  Top Layer w8: U1.38@723.16,703.87 v1@723.16,756.68
  Signal Layer 1 w8: v1(723.48,757) 723.48,872.48 1183,1332 ; J6.3@1180,1657.91 J6.3@1183,1654.91
  Signal Layer 1 w12: 1183,1332 J6.3@1183,1654.91