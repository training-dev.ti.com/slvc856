# Altium PCB DRV81620-Q1EVM-061724.PcbDoc (part 2 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4586.07 x 3253 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 238 components, 136 nets, 678 pads, 298 vias.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
PolygonConnect PolygonConnect_6 [All vs IsNamedPolygon('TOP_LAYER_VM_P042')] p89: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_5 [All vs IsNamedPolygon('TOP_LAYER_VM_P044')] p90: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_4 [All vs IsNamedPolygon('TOP_LAYER_VM_P046')] p91: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_3 [All vs IsNamedPolygon('TOP_LAYER_GND_P036') Or  IsNamedPolygon('TOP_LAYER_OUT2_P040') Or  IsNamedPolygon('TOP_LAYER_OUT1_P038')] p92: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_2 [InNet('EZFET_VBUS') vs IsNamedPolygon('TOP_LAYER_EZFET_VBUS_P008')] p93: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_1 [InNetClass('Power-Net') vs IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201')] p94: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect [All] p95: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
RoutingVias ThermalPadVias [IsVia and InAnyComponent] p1: holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62
RoutingVias [All] p2: holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
SilkToBoardRegionClearance [Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)] p1:
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [(HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small')) vs (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))] p1: silktosilkclearance=0
SilkToSilkClearance [All] p2: silktosilkclearance=3.94
SilkToSolderMaskClearance SilkToComponentPadClearance [(IsPad or IsFill or IsRegion) and InAnycomponent] p1: minsilkscreentomaskgap=5 clearancetoexposedcopper=TRUE
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p2: minsilkscreentomaskgap=3.94 clearancetoexposedcopper=FALSE
SolderMaskExpansion [All] p1: expansion=1.97 istentingtop=FALSE
UnRoutedNet [All] p1: checkbadconnections=TRUE
Width [All] p1: maxlimit=65 minlimit=6 preferedwidth=8 minimp=50.000000 maximp=50.000000 favimp=50.000000 checkconnectedcopper=TRUE
13 further rules are at their usual default settings.

## Classes and differential pairs
component class MD088E1_DRV81xxx: C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C16 C55 C56 D20 F1 J1 J4 J5 J8 J12 J13 J14 J15 J16 J17 J18 J19 J20 J21 J22 J23 J24 J25 J26 J27 J28 J29 L3 R1 R3 R4 R97 R98 TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 TP37 TP38 TP39 TP40 TP41 U4 U5 VM
component class MD088E1_Hardware: FID1 FID2 FID3 LBL1 LBL2 Logo1 Logo2 Logo4 Logo5 LOGO6
component class Logo: Logo2
component class Label: LBL1 LBL2
component class FiducialMark: FID1 FID2 FID3
component class MD088E1_MCU: C15 C41 C44 C45 C46 C49 C50 C51 C52 C53 C54 C59 D3 D5 D6 D8 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 J6 J7 R9 R18 R19 R30 R31 R32 R37 R39 R40 R41 R43 R45 R47 R48 R49 R51 R52 R53 R54 R80 R81 R82 R83 R84 R85 R86 R87 R88 R90 R91 R92 R93 R94 R95 R96 S1 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J36 TP19 TP20 TP21 TP22 TP23 TP24 TP25 TP26 TP27 TP28 TP29 TP30 TP31 TP32 TP33 TP34 TP35 TP36 U1 Y2
component class Shunt: SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J27 SH-J28 SH-J31 SH-J32 SH-J33 SH-J35 SH-J36
net class Power-Net: EZFET_VBUS EZFET_VCC GND MCU_3V3
component class Header: J1 J2 J6 J7 J9 J10 J14 J15 J16 J17 J20 J21 J22 J23 J26 J27 J28 J29
component class MD088E1_ezFET: C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C42 C43 C47 C48 D1 D2 J2 J9 J10 J11 L1 L2 R55 R56 R57 R58 R59 R60 R61 R62 R63 R64 R65 R66 R67 R68 R72 R75 R76 R77 R78 SH-J27 SH-J28 SH-J31 SH-J32 SH-J33 SH-J35 U2 U3 U6 Y1
differential pair USB_D: +USB_D_P -USB_D_N
differential pair EZFET_D: +EZFET_D_P -EZFET_D_N

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
C1 "12061C683KAT2A" 1206 3889,2928 r0 top value=0.068uF
C2 "ZRB18AR61E106ME01L" FP-ZRB18AR61E106ME01L_0603-MFG 3360.51,2890 r0 top value=10µF
C3 "UMK107AB7105KA-T" FP-0603-L_1_6_0_15-W_0_8-IPC_C 4063.03,3586.82 r270 top
C4 "UMK107AB7105KA-T" FP-0603-L_1_6_0_15-W_0_8-IPC_C 3372,2591 r270 top
C5 "885012206095" FP-885012206095-MFG 4140,3586.22 r270 top value=100nF
C6 "885012206095" 0603 2978,3719 r270 top value=0.1uF
C7 "885012107011" 0805_150 2589,3709 r270 top value=22uF
C8 "CC0603KPX7R9BB103" FP-CC0603-DA-MFG 3530,2585 r90 top value="10 nF"
C9 "885012205018" FP-885012205018_0402-MFG 3485,3094.69 r90 top value=100nF
C10 "885012206095" FP-885012206095-MFG 3451,2587 r270 top value=100nF
C11 "CC0603KPX7R9BB103" FP-CC0603-DA-MFG 4220,3586.22 r90 top value="10 nF"
C12 "1nF" FP-C0603C-CF-MFG 4300,3586.22 r270 top value="1,000 pF"
C13 "EEE-FK1H151P" SM_RADIAL_G 4186.22,3870.14 r0 top value=150uF
C14 "EEE-FK1H151P" SM_RADIAL_G 3910,2650 r0 top value=150uF
C15 "885012206095" 0603 250,2800 r180 top value=0.1uF
C16 "1nF" FP-C0603C-CF-MFG 3610,2590 r270 top value="1,000 pF"
C20 "885012106012" FP-885012106012_0603-MFG 1295.47,4175 r0 top value=4.7µF
C21 "885012206095" 0603 1300,4250 r180 top value=0.1uF
C22 "885012005058" FP-885012005058_0402-MFG 475,4150 r180 top value=33pF
C23 "885012006085" FP-885012006085_0603-MFG 475,4300 r180 top value=1nF
C24 "885012005058" FP-885012005058_0402-MFG 475,4200 r180 top value=33pF
C25 "885012206095" 0603 225,3725 r180 top value=0.1uF
C26 "885012005055" 0402 900,3375 r270 top value=10pF
C27 "885012005055" 0402 825,3375 r270 top value=10pF
C28 "885012206048" 0603L 700,4025 r90 top value=0.22uF
C29 "885012206050" FP-885012206050_0603-MFG 225,3575 r0 top value=470nF
C30 "885012206048" 0603L 775,4025 r90 top value=0.22uF
C31 "875105240001" FP-875105240001_SMT_CAP_4MM3_4MM3-MFG 950,3675 r180 top value=10µF
C32 "885012206095" 0603 225,3650 r180 top value=0.1uF
C33 "885012206095" 0603 775,4175 r270 top value=0.1uF
C34 "885012206095" 0603 525,3375 r90 top value=0.1uF
C35 "885012206052" 0603 625,4300 r90 top value=1uF
C36 "885012206095" 0603 700,4175 r270 top value=0.1uF
C37 "885012206040" 0603 1025,4320 r180 top value=0.01uF
C38 "885012106018" 0603 850,4025 r90 top value=2.2uF
C39 "885012206040" 0603 1000,4025 r270 top value=0.01uF
C40 "885012206052" 0603 925,4025 r90 top value=1uF
C41 "885012006085" FP-885012006085_0603-MFG 1570,3170 r180 top value=1nF
C42 "885012005055" 0402 1100,4025 r90 top value=10pF
C43 "885012005055" 0402 1250,4025 r90 top value=10pF
C44 "885012005055" 0402 265,2375 r180 top value=10pF
C45 "885012005055" 0402 250,2525 r180 top value=10pF
C46 "885012206095" 0603 297.02,1983.23 r0 top value=0.1uF
C47 "885012206048" 0603L 1475,4450 r0 top value=0.22uF
C48 "885012206095" 0603 850,4300 r270 top value=0.1uF
C49 "885012206050" FP-885012206050_0603-MFG 484.94,2060.9 r0 top value=470nF
C50 "885012206095" 0603 250,2600 r180 top value=0.1uF
C51 "875105240001" FP-875105240001_SMT_CAP_4MM3_4MM3-MFG 206.98,2245.41 r0 top value=10µF
C52 "885012206095" 0603 297.02,2044.31 r180 top value=0.1uF
C53 "885012206095" 0603 297.02,2105.92 r180 top value=0.1uF
C54 "885012206095" 0603 630,2880 r270 top value=0.1uF
C55 "885012206114" 0603 4387.5,2368 r180 top value=0.01uF
C56 "885012206114" 0603 4387.02,1831.06 r180 top value=0.01uF
C59 "885012006085" FP-885012006085_0603-MFG 1485,3970 r270 top value=1nF
D1 "150060SS75000" WL-SMCW_RED 275,3925 r270 top value="Super Red"
D2 "150060VS75000" WL-SMCW_GREEN 175,3925 r270 top value=Green
D3 "150080SS75000" FP-150080SS75000-MFG 1356.39,1860 r90 top (schematic designator S)
D5 "150080VS75000" 0805_A 396.79,1860.48 r90 top
D6 "150080VS75000" 0805_A 3400,3768.66 r90 top
D8 "150080VS75000" 0805_A 714.26,1859 r90 top
D10 "150080VS75000" 0805_A 1032.04,1858 r90 top
D11 "150080VS75000" 0805_A 1190.94,1858 r90 top
D12 "150080VS75000" 0805_A 1680,2273.09 r90 top
D13 "150080VS75000" 0805_A 1820,2273.09 r90 top
D14 "150080VS75000" 0805_A 1955,2273.09 r90 top
D15 "150080VS75000" 0805_A 2095,2273.09 r90 top
D16 "150080VS75000" 0805_A 1680,2084.09 r270 top
D17 "150080VS75000" 0805_A 1820,2084.09 r270 top
D18 "150080VS75000" 0805_A 1955,2084.09 r270 top
D19 "150080VS75000" 0805_A 2095,2084.09 r270 top
D20 "MMSZ4682-E3-08" SOD-123 4500,3820 r90 top value=2.7V
F1 "0466003.NR" 1206 4400,3554 r270 top
FID1 "Fiducial" Fiducial10-20 95,1520 r0 top
FID2 "Fiducial" Fiducial10-20 4485,1645 r0 top
FID3 "Fiducial" Fiducial10-20 95,4605 r0 top
J1 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3470,2805 r270 top
J2 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 160,3130 r270 top
J4 "1888700" FP-1888700_HDR4-MFG 2829,1649 r0 top
J5 "1888700" FP-1888700_HDR4-MFG 3796,4474.94 r180 top
J6 "61300311121" WURTH_61300311121 1282,3091.91 r180 top
J7 "PEC10DAAN" SULLINS_PEC10DAAN 1975,3065 r180 top
J8 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 4254.96,3178.19 r90 top
J9 "61301421121" WURTH_61301421121 535,4513 r270 top
J10 "61301421121" WURTH_61301421121 659,3160.02 r270 top
J11 "629105150921" FP-629105150921_CONN_PTH_USB_8MM0_5MM6-MFG 1173.27,4609.5 r180 top
J12 "691101710002" 691101710002 4398.83,2609.06 r90 top
J13 "691101710002" 691101710002 4398.83,2101.85 r90 top
J14 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 2979,1916.34 r0 top
J15 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3946,4197 r180 top
J16 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 2679,1915 r180 top
J17 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3644,4193 r0 top
J18 "1888700" FP-1888700_HDR4-MFG 2008,4474.94 r180 top
J19 "1888700" FP-1888700_HDR4-MFG 3746,1649 r0 top
J20 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 1856,4193 r180 top
J21 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3795,1915 r180 top
J22 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 2158,4194.34 r0 top
J23 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3544,1915 r180 top
J24 "1888700" FP-1888700_HDR4-MFG 1920,1649 r0 top
J25 "1888700" FP-1888700_HDR4-MFG 2879,4474.94 r180 top
J26 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 1311,1577 r180 top
J27 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3029,4194.34 r0 top
J28 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 2394,1916.34 r0 top
J29 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 2730,4193 r180 top
L1 "742792621" 0603L 1300,4375 r0 top value="140 ohm"
L2 "742792621" 0603L 1025,4375 r180 top value="140 ohm"
L3 "7443320100" WE-HCC_1210 3680,3730 r270 top value=1uH
LBL1 "THT-14-423-10" Label_650x200 1237,2437 r90 top
LBL2 "EVM Folder" Label_375x375 2815,2740 r0 top
Logo1 "CE Mark" CE_Mark_5mm 3215,2764 r180 bottom
Logo2 "Texas Instruments" TI_Stacked_Overlay_Small 1707.52,3014.13 r90 top
Logo4 "WEEE logo" WEEE_Minimum 2839,2771 r180 bottom
Logo5 "CAUTION.  READ USER GUIDE BEFORE USE" IEC_Caution_Small 2820,3360 r0 top
LOGO6 "CAUTION HOT SURFACE" IEC_HotSurface_Small 2825,3090 r0 top
R1 "SG73S1JTTD101J" FP-SG73S1JTTD101J_0603-MFG 3465,2995 r90 top value=100
R3 "Resistor" 0603L 2919.56,3811 r0 top value=0
R4 "Resistor" 0603L 2649.44,3810 r0 top value=0
R9 "560050310009" FP-560050310009_0402-MFG 250,2725 r180 top value=10
R18 "CRCW040247K0JNED" 0402 725,2875 r270 top value=47k
R19 "CRCW040247K0JNED" 0402 1580,3965 r90 top value=47k
R30 "RC0603JR-0710KL" 0603L 1420,2845.44 r270 top value=10k
R31 "RC0603JR-0710KL" 0603L 1515,2962.44 r270 top value=10k
R32 "RC0603JR-0710KL" 0603L 1515,2845.44 r270 top value=10k
R37 "560050310009" FP-560050310009_0402-MFG 250,2675 r0 top value=10
R39 "RC0603JR-0710KL" 0603L 1165,2960 r270 top value=10k
R40 "RC0603JR-0710KL" 0603L 1252.2,2957.56 r270 top value=10k
R41 "RC0603JR-0710KL" 0603L 1335,2960.75 r270 top value=10k
R43 "CRCW06034K99FKEAC" 0603L 3399.98,3628.31 r90 top value=4.99k
R45 "Resistor" 0603L 714.24,1717.65 r90 top value=330
R47 "Resistor" 0603L 1032.03,1716.65 r90 top value=330
R48 "Resistor" 0603L 1190.92,1716.65 r90 top value=330
R49 "Resistor" 0603L 396.45,1720.12 r90 top value=330
R51 "RC0603JR-0710KL" 0603L 1165,2845.44 r270 top value=10k
R52 "RC0603JR-0710KL" 0603L 1252.2,2845.44 r270 top value=10k
R53 "RC0603JR-0710KL" 0603L 1335,2845.44 r270 top value=10k
R54 "RC0603JR-0710KL" 0603L 1420,2959.25 r270 top value=10k
R55 "RC0402FR-07220KL" 0402 375,4150 r180 top value=220k
R56 "CRCW0402240KFKED" 0402 375,4200 r180 top value=240k
R57 "CRCW040247K0JNED" 0402 375,4300 r180 top value=47k
R58 "RC0603JR-07470RL" 0603 375,3375 r270 top value=470
R59 "RC0603JR-07560RL" 0603 450,3375 r270 top value=560
R60 "RC0402FR-07220KL" 0402 375,4100 r0 top value=220k
R61 "CRCW0402150KFKED" 0402 375,4250 r0 top value=150k
R62 "Resistor" 0603L 700,4300 r270 top value=0
R63 "Resistor" 0603L 775,4300 r270 top value=0
R64 "560050310009" FP-560050310009_0402-MFG 975,3350 r270 top value=10
R65 "560050310009" FP-560050310009_0402-MFG 750,3350 r270 top value=10
R66 "560050310009" FP-560050310009_0402-MFG 675,3350 r270 top value=10
R67 "560050310009" FP-560050310009_0402-MFG 600,3350 r270 top value=10
R68 "Resistor" 0603L 850,4175 r270 top value=0
R72 "CRCW040227R0JNED" 0402L 1150,4025 r270 top value=27
R75 "CRCW040227R0JNED" 0402L 1200,4025 r270 top value=27
R76 "CRCW04021K40FKED" 0402L 850,3865 r270 top value=1.40k
R77 "CRCW04021M00JNED" 0402L 925,3865 r90 top value=1.0Meg
R78 "CRCW040233K0JNED" 0402S 1475,4500 r180 top value=33k
R80 "Resistor" 0603L 1354.37,1706.88 r90 top value=330
R81 "Resistor" 0603L 1750.61,2214.09 r90 top value=330
R82 "Resistor" 0603L 1895.61,2214.09 r90 top value=330
R83 "Resistor" 0603L 2030.61,2214.09 r90 top value=330
R84 "Resistor" 0603L 2165.61,2214.09 r90 top value=330
R85 "Resistor" 0603L 1750.61,2099.09 r90 top value=330
R86 "Resistor" 0603L 1895.61,2099.09 r90 top value=330
R87 "Resistor" 0603L 2030.61,2099.09 r90 top value=330
R88 "Resistor" 0603L 2165.61,2099.09 r90 top value=330
R90 "RC0402FR-07100RL" 0402S 1435,2745 r0 top value=100
R91 "RC0402FR-07100RL" 0402S 1435,2665 r0 top value=100
R92 "RC0402FR-07100RL" 0402S 1435,2620 r0 top value=100
R93 "RC0402FR-07100RL" 0402S 1435,2705 r0 top value=100
R94 "RC0402FR-07100RL" 0402S 1435,2485 r0 top value=100
R95 "RC0402FR-07100RL" 0402S 1435,2530 r0 top value=100
R96 "RC0402FR-07100RL" 0402S 1435,2570 r0 top value=100
R97 "RG1608P-913-B-T5" 0603L 4500,3610 r180 top value=91.0k
R98 "RG1608P-103-B-T5" 0603L 4500,3680 r0 top value=10.0k
S1 "430481025816" FP-430481025816_SMT_SW_6MM2_6MM2-MFG 1280,3375 r180 top
SH-J6 "60900213421" Wurth_60900213421 1975,3515 r180 top
SH-J7 "60900213421" Wurth_60900213421 1975,3430 r180 top
SH-J8 "60900213421" Wurth_60900213421 1975,3325 r0 top
SH-J9 "60900213421" Wurth_60900213421 1975,3225 r0 top
SH-J10 "60900213421" Wurth_60900213421 1975,3120 r180 top
SH-J11 "60900213421" Wurth_60900213421 1975,3015 r0 top
SH-J12 "60900213421" Wurth_60900213421 1975,2920 r0 top
SH-J19 "60900213421" Wurth_60900213421 1975,2815 r180 top
SH-J27 "60900213421" Wurth_60900213421 962.97,3158.62 r90 top
SH-J28 "60900213421" Wurth_60900213421 862.97,3158.62 r90 top
SH-J31 "60900213421" Wurth_60900213421 762.97,3158.62 r90 top
SH-J32 "60900213421" Wurth_60900213421 562.97,3158.62 r90 top
SH-J33 "60900213421" Wurth_60900213421 662.97,3158.62 r90 top
SH-J35 "60900213421" Wurth_60900213421 1330,3092 r0 top
SH-J36 "60900213421" Wurth_60900213421 1975,2720 r180 top
TP1 "5011" Keystone5011 1322,3734 r0 top
TP2 "5010" Keystone5010 3822,3363 r0 top
TP3 "5012" Keystone5012 4067,2332 r0 top
TP4 "5011" Keystone5011 3234,2096 r270 top
TP5 "5012" Keystone5012 4096,2005 r0 top
TP6 "5011" Keystone5011 2461,4038 r270 top
TP7 "5010" Keystone5010 2928,2096 r180 top
TP8 "5010" Keystone5010 2729,2096 r0 top
TP9 "5010" Keystone5010 4196,4197 r0 top
TP10 "5010" Keystone5010 3434,4189 r180 top
TP11 "5010" Keystone5010 1911,4038 r0 top
TP12 "5010" Keystone5010 3845,2074 r0 top
TP13 "5010" Keystone5010 2108,4038 r0 top
TP14 "5010" Keystone5010 3594,2074 r90 top
TP15 "5010" Keystone5010 1477,2007 r0 top
TP16 "5010" Keystone5010 2981,4038 r180 top
TP17 "5010" Keystone5010 2346,2096 r180 top
TP18 "5010" Keystone5010 2779,4038 r0 top
TP19 "TP_H0.45P0.75" TP_H045P075 800,1905 r0 top
TP20 "5002" Keystone5002 2161.65,2530 r0 top
TP21 "5002" Keystone5002 2156.65,2665 r0 top
TP22 "5002" Keystone5002 2156.65,2795 r0 top
TP23 "5002" Keystone5002 2161.65,2930 r0 top
TP24 "5002" Keystone5002 2171.65,3075 r0 top
TP25 "5002" Keystone5002 2165.84,3214.86 r180 top
TP26 "5002" Keystone5002 2166.65,3345 r180 top
TP27 "5002" Keystone5002 2161.65,3475 r180 top
TP28 "5002" Keystone5002 2170,3605 r180 top
TP29 "TP_H0.45P0.75" TP_H045P075 170.44,1619.82 r0 top
TP30 "TP_H0.45P0.75" TP_H045P075 170.44,1784.07 r90 top
TP31 "TP_H0.45P0.75" TP_H045P075 170.44,1701.94 r90 top
TP32 "TP_H0.45P0.75" TP_H045P075 170.44,2030.44 r0 top
TP33 "TP_H0.45P0.75" TP_H045P075 170.44,1948.32 r90 top
TP34 "TP_H0.45P0.75" TP_H045P075 170.44,1866.19 r0 top
TP35 "5011" Keystone5011 175,3400 r0 top
TP36 "5003" Keystone5003 420,2935 r0 top
TP37 "Jumper_2p" Harwin_D3082-05 2714,2468 r180 top
TP38 "Jumper_2p" Harwin_D3082-05 1998,3779 r0 top
TP39 "Jumper_2p" Harwin_D3082-05 2538,3085 r270 top
TP40 "5010" Keystone5010 3138,3804 r90 top
TP41 "5010" Keystone5010 4341,4492 r0 top
U1 "MSP430F5338IPZ" PZT0100A_N 725.16,2442 r0 top locked
U2 "MSP430F5528IRGCT" RGC0064B 563.85,3716.66 r0 top
U3 "TPS73533DRBR" DRB0008A 1000,4200 r90 top
U4 "LM9036M-3.3/NOPB" D0008A_N 2784.28,3677.19 r0 top
U5 "DRV81620HTSSOP" PWP0024T-MFG 3270,3140 r270 top locked
U6 "TPD2E001DRYR" DRY0006A 1165.32,4351.81 r90 top
VM "5010" Keystone5010 3819,3085 r0 top
Y1 "CSTNR4M00GH5L000R0" MURATA_CSTNR 550.36,4011.69 r180 top
Y2 "MS3V-T1R 32.768KHZ +/-20PPM 12.5PF" XTAL_MS3V-T1R 240.55,2448.95 r180 top

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
0402 [mm] "0402 from SM-752 data"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -1.22,-0.52 1.22,0.52, body extent -0.55,-0.3 0.55,0.3, height 0.6
0402L [mm] "0402 from SM-752 data"
  rect 0.6x0.5 smd: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.8,-0.55 0.8,0.55, body extent -0.55,-0.3 0.55,0.3, height 0.6
0402S [mil] "Based on C0402S footprint from PADS legacy"
  rect 15x24 smd: 1(-20,0) 2(20,0)
  silkscreen extent -32,-22 32,22, body extent -22,-12 22,12, height 24
0603 [mm] "0603 from SM-752 data"
  rect 1x0.95 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.52,-0.69 1.52,0.69, body extent -0.87,-0.47 0.87,0.47, height 1
0603L [mm] "0603 from SM-752 data"
  rect 0.92x0.97 smd mask+0.038: 1(-0.775,0) 2(0.775,0)
  silkscreen extent -0.07,-0.33 0.07,0.33, body extent -0.87,-0.47 0.87,0.47, height 1
0805_150 [mm] "0805 / 1.5 mm height"
  rect 1.15x1.45 smd: 1(-0.9,0) 2(0.9,0)
  silkscreen extent -0.1,-0.8 0.1,0.8, body extent -1.1,-0.72 1.1,0.72, height 1.5
0805_A [mm] "Chip LED, 2-Leads, Body 2.0x1.3mm, IPC Medium Density"
  rect 1.1x1.2 smd: 1(-1.05,0) 2(1.05,0)
  silkscreen extent -0.15,-0.5 2.98,0.5, body extent -1,-0.62 1,0.63, height 0.68
1206 [mm] "1206 from SM-752 data"
  rect 1.3x1.85 smd: 1(-1.45,0) 2(1.45,0)
  silkscreen extent -2.4,-1.21 2.4,1.21, body extent -1.7,-0.9 1.7,0.9, height 1.35
691101710002 [mm] "5,00mm - modular - blue - Horizontal entry with pressure clamp - 12,6mm height - 02p"
  rect 1.95x1.95 hole 1.3: 1(-2.5,-0.5)
  round 1.95 hole 1.3: 2(2.5,-0.5)
  silkscreen extent -6.73,-4.5 5.6,4.5, body extent -5.6,-4.5 5.6,4.5, height 12.65
CE_Mark_5mm [mil] "Minimum text height for CE Mark"
  silkscreen extent -138,-98 138,98
D0008A_N [mm] "SOIC, 8-Leads, Body 4.9x3.9mm, Pitch 1.27mm, IPC Medium Density"
  oval 1.45x0.6 smd: 1(-2.725,1.905) 2(-2.725,0.635) 3(-2.725,-0.635) 4(-2.725,-1.905) 5(2.725,-1.905) 6(2.725,-0.635) 7(2.725,0.635) 8(2.725,1.905)
  silkscreen extent -3.3,-2.5 0.9,2.5, body extent -3,-2.45 3,2.45, height 1.63
DRB0008A [mm] "VSON-8"
  rrect32% 0.6x0.31 smd: 1(-1.4,0.975) 2(-1.4,0.325) 3(-1.4,-0.325) 4(-1.4,-0.975) 5(1.4,-0.975) 6(1.4,-0.325) 7(1.4,0.325) 8(1.4,0.975)
  rrect7% 1.5x1.75 smd paste-0.75: 9(0,0)
  Top Layer region: -0.7,-0.875 -0.49,-0.875 -0.471,-0.879 -0.455,-0.89 -0.444,-0.906 -0.44,-0.925 -0.44,-0.925 -0.44,-1.65 -0.436,-1.669 -0.425,-1.685 -0.409,-1.696 -0.39,-1.7 -0.39,-1.7 -0.26,-1.7 -0.241,-1.696 -0.225,-1.685 -0.214,-1.669 -0.21,-1.65 -0.21,-1.65 -0.21,-0.925 -0.206,-0.906 -0.195,-0.89 -0.179,-0.879 -0.16,-0.875 -0.16,-0.875 0.16,-0.875 0.179,-0.879 0.195,-0.89 0.206,-0.906 0.21,-0.925 0.21,-0.925 0.21,-1.65 0.214,-1.669 0.225,-1.685 0.241,-1.696 0.26,-1.7 0.26,-1.7 0.39,-1.7 0.409,-1.696 0.425,-1.685 0.436,-1.669 0.44,-1.65 0.44,-1.65 0.44,-0.925 0.444,-0.906 0.455,-0.89 0.471,-0.879 0.49,-0.875 0.49,-0.875 0.7,-0.875 0.719,-0.871 0.735,-0.86 0.746,-0.844 0.75,-0.825 0.75,-0.825 0.75,0.825 0.746,0.844 0.735,0.86 0.719,0.871 0.7,0.875 0.7,0.875 0.49,0.875 0.471,0.879 0.455,0.89 0.444,0.906 0.44,0.925 0.44,0.925 0.44,1.65 0.436,1.669 0.425,1.685 0.409,1.696 0.39,1.7 0.39,1.7 0.26,1.7 0.241,1.696 0.225,1.685 0.214,1.669 0.21,1.65 0.21,1.65 0.21,0.925 0.206,0.906 0.195,0.89 0.179,0.879 0.16,0.875 0.16,0.875 -0.16,0.875 -0.179,0.879 -0.195,0.89 -0.206,0.906 -0.21,0.925 -0.21,0.925 -0.21,1.65 -0.214,1.669 -0.225,1.685 -0.241,1.696 -0.26,1.7 -0.26,1.7 -0.39,1.7 -0.409,1.696 -0.425,1.685 -0.436,1.669 -0.44,1.65 -0.44,1.65 -0.44,0.925 -0.444,0.906 -0.455,0.89 -0.471,0.879 -0.49,0.875 -0.49,0.875 -0.7,0.875 -0.719,0.871 -0.735,0.86 -0.746,0.844 -0.75,0.825 -0.75,0.825 -0.75,-0.825 -0.746,-0.844 -0.735,-0.86 -0.719,-0.871 -0.7,-0.875
  silkscreen extent -1.73,-1.73 1.73,1.73, body extent -1.5,-1.5 1.5,1.5, height 0.77
DRY0006A [mm] "USON-6"
  rrect67% 0.45x0.3 smd paste+0 mask+0: 1(-0.275,0.5)
  rrect67% 0.4x0.3 smd paste+0 mask+0: 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
  silkscreen extent -1.14,-0.98 0.75,0.98, body extent -0.5,-0.72 0.5,0.73, height 0.58
Fiducial10-20 [mm]
  round 1 smd mask+0.5: 1(0,0)
  Top Layer keep-out circle w1.178: c0,0 r0.5
FP-0603-L_1_6_0_15-W_0_8-IPC_C [mil]
  rect 33.77x33.94 smd paste+0 mask+0: 1(-23.71,0) 2(23.71,0)
  silkscreen extent -41,-34 41,34, body extent -45,-23 45,23, height 10
FP-150080SS75000-MFG [mm]
  rect 1.1x1.2 smd paste+0 mask+0: 1(-1.05,0) 2(1.05,0)
  silkscreen extent -0.13,-0.67 0.13,0.67, body extent -1.7,-0.77 1.7,0.77, height 0.25
FP-1888700_HDR4-MFG [mil]
  rect 74.24x74.25 hole 54.24 paste-39370.1 mask+0: 1(-300,0)
  oval 74.24x74.25 hole 54.24 paste-39370.1 mask+0: 2(-100,0) 3(100,0) 4(300,0)
  silkscreen extent -459,-204 418,204, body extent -408,-194 408,194, height 10
FP-430481025816_SMT_SW_6MM2_6MM2-MFG [mm]
  rrect7% 2x1.4 smd paste+0 mask+0: 1(-3.5,2) 2(3.5,2) 3(-3.5,-2) 4(3.5,-2)
  silkscreen extent -5.18,-3.2 3.2,3.2, body extent -4.6,-3.3 4.6,3.3, height 0.25
FP-560050310009_0402-MFG [mm]
  rrect25% 0.4x0.5 smd paste+0 mask+0: 1(-0.45,0) 2(0.45,0)
  silkscreen extent -0.5,-0.63 0.5,0.63, body extent -0.75,-0.38 0.75,0.38, height 0.25
FP-629105150921_CONN_PTH_USB_8MM0_5MM6-MFG [mm]
  rrect25% 0.4x1.35 smd paste+0 mask+0: 1(-1.3,2.335) 2(-0.65,2.335) 3(0,2.335) 4(0.65,2.335) 5(1.3,2.335)
  rrect100% 1.15x1.05 hole 0.65 slot 0.75 at 0 deg paste-1000 mask+0: 6(-2.225,2.65) 7(2.225,2.65)
  rrect100% 1.35x1.9 hole 1.3 slot 0.75 at 0 deg paste-1000 mask+0: 8(-4.175,-0.47) 11(4.173,-0.47)
  round 1.71 smd paste+0 mask+0: 8(-3.699,-0.47) 11(3.699,-0.47)
  rrect6% 1.8x1.9 smd paste+0 mask+0: 9(-1.15,-0.47) 10(1.15,-0.47)
  Top Layer region: -2.6,-1.42 -4.35,-1.42 -4.449,-1.42 -4.633,-1.344 -4.774,-1.203 -4.85,-1.019 -4.85,-0.92 -4.85,-0.92 -4.85,-0.02 -4.85,0.079 -4.774,0.263 -4.633,0.404 -4.449,0.48 -4.35,0.48 -4.35,0.48 -2.6,0.48
  Top Layer region: 2.6,0.48 4.35,0.48 4.449,0.48 4.633,0.404 4.774,0.263 4.85,0.079 4.85,-0.02 4.85,-0.02 4.85,-0.92 4.85,-1.019 4.774,-1.203 4.633,-1.344 4.449,-1.42 4.35,-1.42 4.35,-1.42 2.6,-1.42
  silkscreen extent -3.8,-2.16 5.46,3.71, body extent -4.95,-2.7 4.95,3.27, height 0.25
FP-691250610002_CONN_TERM_BLOCK2-MFG [mm]
  rrect4% 2.3x2.3 hole 1.5 paste-1000 mask+0: 1(-2.875,1.65)
  round 2.3 hole 1.5 paste-1000 mask+0: 2(3.475,1.65)
  silkscreen extent -7.52,-6.3 6.85,6.3, body extent -6.95,-6.4 6.95,6.4, height 0.25
FP-875105240001_SMT_CAP_4MM3_4MM3-MFG [mm]
  rrect6% 2.6x1.6 smd paste+0 mask+0: 1(-1.8,0) 2(1.8,0)
  silkscreen extent -2.25,-2.25 4.38,2.25, body extent -3.35,-2.5 3.35,2.5, height 0.25
FP-885012005058_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.53,-0.63 0.53,0.63, body extent -0.85,-0.38 0.85,0.38, height 0.25
FP-885012006085_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77, body extent -1.25,-0.55 1.25,0.55, height 0.25
FP-885012106012_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77, body extent -1.25,-0.55 1.25,0.55, height 0.25
FP-885012205018_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.5,-0.63 0.5,0.63, body extent -0.5,-0.25 0.5,0.25, height 0.55
FP-885012206050_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77, body extent -1.25,-0.55 1.25,0.55, height 0.25
FP-885012206095-MFG [mm]
  rect 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77, body extent -1.25,-0.55 1.25,0.55, height 0.25
FP-C0603C-CF-MFG [mm]
  rect 0.75x0.9 smd paste+0 mask+0: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -0.87,-0.85 0.88,0.85, body extent -1.2,-0.6 1.2,0.6, height 0.25
FP-CC0603-DA-MFG [mm]
  rect 0.8x0.9 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.85 0.85,0.85, body extent -1.35,-0.75 1.35,0.75, height 0.25
FP-SG73S1JTTD101J_0603-MFG [mm]
  rect 0.92x0.97 smd mask+0.038: 1(-0.775,0) 2(0.775,0)
  silkscreen extent -0.13,-0.45 0.13,0.45, body extent -1.1,-0.55 1.1,0.55, height 0.25
FP-ZRB18AR61E106ME01L_0603-MFG [mm]
  rrect13% 0.75x0.9 smd paste+0 mask+0: 1(-0.775,0) 2(0.775,0)
  silkscreen extent 0,-0.5 0,0.5, body extent -1.25,-0.6 1.25,0.6, height 0.25
Harwin_D3082-05 [mm] "Shorting Plug, 10.16mm spacing, TH"
  round 1.8 hole 1.3: 1(-5.08,0) 2(5.08,0)
  silkscreen extent -3.9,-0.53 3.9,0.53, body extent -5.6,-0.52 5.61,0.52, height 6.63
IEC_Caution_Small [mil]
  silkscreen extent -107,-93 107,92
IEC_HotSurface_Small [mil]
  silkscreen extent -107,-93 107,92
Keystone5002 [mil] "For Keystone 500x miniature loop terminals"
  round 80 hole 40: 1(0,0)
  silkscreen extent -52,-52 52,52, body extent -49,-49 49,49, height 182
Keystone5003 [mil] "For Keystone 500x miniature loop terminals"
  round 80 hole 40: 1(0,0)
  silkscreen extent -52,-52 52,52, body extent -49,-49 49,49, height 182
Keystone5010 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
Keystone5011 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
Keystone5012 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
Label_375x375 [mil] "Thermal Transfer Label"
  round 1 on Mech13: 0(0,0)
  silkscreen extent -188,-188 188,188, body extent -188,-188 188,188, height 1
Label_650x200 [mil] "Thermal Transfer Label"
  round 1 on Mech13: 0(0,0)
  silkscreen extent -325,-100 325,100, body extent -325,-100 325,100, height 1
MURATA_CSTNR [mm] "SMD, 3-Leads, Body 4.5x2mm, Pitch 1.5mm"
  rrect25% 0.4x2.6 smd: 1(-1.5,0) 2(0,0) 3(1.5,0)
  silkscreen extent -2.79,-1.28 2.55,1.3, body extent -2.3,-1.05 2.3,1.05, height 1.2
PWP0024T-MFG [mm]
  rrect22% 1.5x0.45 smd paste+0 mask+0: 1(-2.9,3.575) 2(-2.9,2.925) 3(-2.9,2.275) 4(-2.9,1.625) 5(-2.9,0.975) 6(-2.9,0.325) 7(-2.9,-0.325) 8(-2.9,-0.975) 9(-2.9,-1.625) 10(-2.9,-2.275) 11(-2.9,-2.925) 12(-2.9,-3.575) 13(2.9,-3.575) 14(2.9,-2.925) 15(2.9,-2.275) 16(2.9,-1.625) 17(2.9,-0.975) 18(2.9,-0.325) 19(2.9,0.325) 20(2.9,0.975) 21(2.9,1.625) 22(2.9,2.275) 23(2.9,2.925) 24(2.9,3.575)
  rrect3% 3.4x7.8 smd paste+0 mask+0: 25(0,0)
  silkscreen extent -4.32,-4.28 2.25,4.28, body extent -3.75,-4.2 3.75,4.2, height 0.25
PZT0100A_N [mm] "QFP, 100-Leads, Body 14x14mm, Pitch 0.50mm, IPC Medium Density"
  oval 1.45x0.3 smd: 1(-7.725,6) 2(-7.725,5.5) 3(-7.725,5) 4(-7.725,4.5) 5(-7.725,4) 6(-7.725,3.5) 7(-7.725,3) 8(-7.725,2.5) 9(-7.725,2) 10(-7.725,1.5) 11(-7.725,1) 12(-7.725,0.5) 13(-7.725,0) 14(-7.725,-0.5) 15(-7.725,-1) 16(-7.725,-1.5) 17(-7.725,-2) 18(-7.725,-2.5) 19(-7.725,-3) 20(-7.725,-3.5) 21(-7.725,-4) 22(-7.725,-4.5) 23(-7.725,-5) 24(-7.725,-5.5) 25(-7.725,-6) 51(7.725,-6) 52(7.725,-5.5) 53(7.725,-5) 54(7.725,-4.5) 55(7.725,-4) 56(7.725,-3.5) 57(7.725,-3) 58(7.725,-2.5) 59(7.725,-2) 60(7.725,-1.5) 61(7.725,-1) 62(7.725,-0.5) 63(7.725,0) 64(7.725,0.5) 65(7.725,1) 66(7.725,1.5) 67(7.725,2) 68(7.725,2.5) 69(7.725,3) 70(7.725,3.5) 71(7.725,4) 72(7.725,4.5) 73(7.725,5) 74(7.725,5.5) 75(7.725,6)
  oval 0.3x1.45 smd: 26(-6,-7.725) 27(-5.5,-7.725) 28(-5,-7.725) 29(-4.5,-7.725) 30(-4,-7.725) 31(-3.5,-7.725) 32(-3,-7.725) 33(-2.5,-7.725) 34(-2,-7.725) 35(-1.5,-7.725) 36(-1,-7.725) 37(-0.5,-7.725) 38(0,-7.725) 39(0.5,-7.725) 40(1,-7.725) 41(1.5,-7.725) 42(2,-7.725) 43(2.5,-7.725) 44(3,-7.725) 45(3.5,-7.725) 46(4,-7.725) 47(4.5,-7.725) 48(5,-7.725) 49(5.5,-7.725) 50(6,-7.725) 76(6,7.725) 77(5.5,7.725) 78(5,7.725) 79(4.5,7.725) 80(4,7.725) 81(3.5,7.725) 82(3,7.725) 83(2.5,7.725) 84(2,7.725) 85(1.5,7.725) 86(1,7.725) 87(0.5,7.725) 88(0,7.725) 89(-0.5,7.725) 90(-1,7.725) 91(-1.5,7.725) 92(-2,7.725) 93(-2.5,7.725) 94(-3,7.725) 95(-3.5,7.725) 96(-4,7.725) 97(-4.5,7.725) 98(-5,7.725) 99(-5.5,7.725) 100(-6,7.725)
  silkscreen extent -8.1,-8.2 8.1,8.2, body extent -8.01,-8.01 8.01,8.01, height 1.6
RGC0064B [mm] "VQFN-64"
  rrect42% 0.6x0.24 smd mask+0.07: 1(-4.4,3.75) 2(-4.4,3.25) 3(-4.4,2.75) 4(-4.4,2.25) 5(-4.4,1.75) 6(-4.4,1.25) 7(-4.4,0.75) 8(-4.4,0.25) 9(-4.4,-0.25) 10(-4.4,-0.75) 11(-4.4,-1.25) 12(-4.4,-1.75) 13(-4.4,-2.25) 14(-4.4,-2.75) 15(-4.4,-3.25) 16(-4.4,-3.75) 33(4.4,-3.75) 34(4.4,-3.25) 35(4.4,-2.75) 36(4.4,-2.25) 37(4.4,-1.75) 38(4.4,-1.25) 39(4.4,-0.75) 40(4.4,-0.25) 41(4.4,0.25) 42(4.4,0.75) 43(4.4,1.25) 44(4.4,1.75) 45(4.4,2.25) 46(4.4,2.75) 47(4.4,3.25) 48(4.4,3.75)
  rrect42% 0.24x0.6 smd mask+0.07: 17(-3.75,-4.4) 18(-3.25,-4.4) 19(-2.75,-4.4) 20(-2.25,-4.4) 21(-1.75,-4.4) 22(-1.25,-4.4) 23(-0.75,-4.4) 24(-0.25,-4.4) 25(0.25,-4.4) 26(0.75,-4.4) 27(1.25,-4.4) 28(1.75,-4.4) 29(2.25,-4.4) 30(2.75,-4.4) 31(3.25,-4.4) 32(3.75,-4.4) 49(3.75,4.4) 50(3.25,4.4) 51(2.75,4.4) 52(2.25,4.4) 53(1.75,4.4) 54(1.25,4.4) 55(0.75,4.4) 56(0.25,4.4) 57(-0.25,4.4) 58(-0.75,4.4) 59(-1.25,4.4) 60(-1.75,4.4) 61(-2.25,4.4) 62(-2.75,4.4) 63(-3.25,4.4) 64(-3.75,4.4)
  rrect2% 4.25x4.25 smd paste-2.112: 65(0,0)
  silkscreen extent -5.21,-4.75 4.75,4.75, body extent -4.5,-4.5 4.5,4.5, height 1
Samtec_HTSW-102-07-G-S [mm] "Samtec 100mil, 1x2, 230 mil above insulator"
  rrect6% 1.65x1.65 hole 1.016: 1(-1.27,0)
  round 1.65 hole 1.016: 2(1.27,0)
  silkscreen extent -3.3,-1.27 2.54,1.27, body extent -2.54,-1.27 2.54,1.27, height 8.38
SM_RADIAL_G [mm] "10 x 10.2mm:  Panasonic G"
  rect 4.1x2 smd: 1(-4.35,0) 2(4.35,0)
  silkscreen extent -6.41,-5.35 5.35,5.35, body extent -5.25,-5.25 5.25,5.25, height 10.5
SOD-123 [mm] "On Semi recommended land pattern"
  rect 0.915x1.22 smd: 1(-1.637,0) 2(1.637,0)
  silkscreen extent -2.74,-1.17 2.03,1.17, body extent -1.93,-0.9 1.93,0.9, height 1.35
SULLINS_PEC10DAAN [mm] "SULLINS"
  rrect50% 1.55x1.55 hole 1.016: 1(-1.27,11.43)
  round 1.55 hole 1.016: 2(1.27,11.43) 3(-1.27,8.89) 4(1.27,8.89) 5(-1.27,6.35) 6(1.27,6.35) 7(-1.27,3.81) 8(1.27,3.81) 9(-1.27,1.27) 10(1.27,1.27) 11(-1.27,-1.27) 12(1.27,-1.27) 13(-1.27,-3.81) 14(1.27,-3.81) 15(-1.27,-6.35) 16(1.27,-6.35) 17(-1.27,-8.89) 18(1.27,-8.89) 19(-1.27,-11.43) 20(1.27,-11.43)
  silkscreen extent -2.9,-12.7 2.54,12.7, body extent -2.54,-12.7 2.54,12.7, height 8.38
TI_Stacked_Overlay_Small [mil]
  silkscreen extent -418,-98 418,98
TP_H045P075 [mm] "TP_H0.45P0.75"
  round 0.75 hole 0.45: 1(0,0)
WE-HCC_1210 [mm] "WURTH"
  rect 2.9x5.4 smd: 1(-4.95,0) 2(4.95,0)
  silkscreen extent -6,-5.9 6,5.9, body extent -6,-5.85 6,5.85, height 10
WEEE_Minimum [mil] "WEEElie bin"
  silkscreen extent -95,-172 99,104
WL-SMCW_GREEN [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8, body extent -0.85,-0.45 0.85,0.45, height 0.8
WL-SMCW_RED [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8, body extent -0.85,-0.45 0.85,0.45, height 0.8
Wurth_60900213421 [mil] "Shunt, 2.54mm, Black"
  round 1 on Mech3: 0(0,0)
  body extent -98,-48 98,48, height 338
WURTH_61300311121 [mm] "Header, 2.54mm, 3x1, TH"
  rrect50% 1.65x1.65 hole 1.15: 1(-2.54,0)
  round 1.65 hole 1.15: 2(0,0) 3(2.54,0)
  silkscreen extent -4.83,-1.52 4.06,1.52, body extent -3.81,-1.27 3.81,1.27, height 8.54
WURTH_61301421121 [mm] "Header, 2.54mm, 7x2, TH"
  rrect50% 1.65x1.65 hole 1.1: 1(-1.27,7.62)
  round 1.65 hole 1.1: 2(1.27,7.62) 3(-1.27,5.08) 4(1.27,5.08) 5(-1.27,2.54) 6(1.27,2.54) 7(-1.27,0) 8(1.27,0) 9(-1.27,-2.54) 10(1.27,-2.54) 11(-1.27,-5.08) 12(1.27,-5.08) 13(-1.27,-7.62) 14(1.27,-7.62)
  silkscreen extent -3.56,-9.14 2.79,9.14, body extent -2.54,-8.89 2.54,8.89, height 8.55
XTAL_MS3V-T1R [mm] "Micro Crystal Switzerland recommended land pattern"
  rect 1.1x0.6 smd: 1(-2.775,0.45) 2(-2.775,-0.45)
  rect 2.4x1.5 smd: 3(2.775,0)
  silkscreen extent -1.9,-0.74 1.2,0.74, body extent -3.05,-0.74 3.65,0.74, height 1.42

## Part data
C1: library part CMP-0008507-2, "CAP, CERM, 0.068 uF, 100 V, +/- 10%, X7R, 1206", Cap_Case=1206, Manufacturer=AVX, Supplier Part Number 1=478-1528-1-ND, TempCo=X7R, Tolerance_%=10%, Value1="0.045 ohm", Value2=100V, ValueDisplayed=0.068uF
C2: library part CMP-0094458-1, "10µF ±20% 25V Ceramic Capacitor X5R 0603 (1608 Metric)", Digikey Part Number=490-10991-1-ND, Manufacturer="Murata Electronics", Mouser Part Number=81-ZRB18AR61E106ME1L, Operating Temperature Range="-55°C to +85°C", Temperature Characteristic=X5R, Tolerance_%=20%, ValueDisplayed=10uF
C3 C4: library part CMP-2000-07531-4, "Ceramic Capacitor General Use 1uF ±10% 50V X7R 0603", Capacitance=1uF, Case Code (Imperial)=0603, Case Code (Metric)=1608, Dielectric=X7R, Max Operating Temperature=125°C, Min Operating Temperature=-55°C, Package Quantity=1, Tolerance=10%, Voltage Rating=50V
C5 C10: library part CMP-207839-000004-1, "CAP CER 0.1UF 50V X7R 0603", Case Code (Imperial)=0603, Case Code (Metric)=1608, Dielectric=X7R, Max Operating Temperature=125°C, Min Operating Temperature=-55°C, Tolerance=10%, Voltage Rating=50V
C6 C15 C21 C25 C32 C33 C34 C36 C46 C48 C50 C52 C53 C54: library part CMP-0006837-4, "CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=50V, ValueDisplayed=0.1uF
C7: library part CMP-0078153-1, "CAP, CERM, 22 µF, 10 V,+/- 20%, X5R, 0805", Cap_Case=0805, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7621-1-ND, TempCo=X5R, Tolerance_%=20%, Value2=10V, ValueDisplayed=22µF
C8 C11: library part CMP-1035-02321-3, "CAP CER 10000PF 50V X7R 0603", Alternative Manufacturer="Wurth Elektronik", Alternative PartNumber=885382206002, Capacitance="10 nF", Manufacturer=YAGEO, Package=CC0603-DA, Temperature="-55°C to +125°C", Temperature Characteristic=X7R, Temperature Coefficient=15%, Temperature Range High=+125°C, Temperature Range Low=-55°C, Tolerance=0.1, Voltage="50 V"
C9: library part CMP-0090362-1, "0.1µF ±10% 10V Ceramic Capacitor X7R 0402 (1005 Metric)", Digikey Part Number=732-7513-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012205018, Operating Temperature Range="-55°C to +125°C", TempCo=15%, Temperature Characteristic=X7R, Tolerance_%=10%, ValueDisplayed=100000pF
C12 C16: library part CMP-03020-030804-1, "CAP CER 1000PF 50V X7R 0603", Alternate Manufacturer="Wurth Elektronik", Alternate PartNumber=885012206083, Capacitance="1,000 pF", Manufacturer=KEMET, Manufacturer Part Number=C0603C102J5RACAUTO, Package=C0603C-CF, Temperature="-55°C to +125°C", Temperature Characteristic=X7R, Temperature Coefficient=30ppm/°C, Temperature Range High=+125°C, Temperature Range Low=-55°C, Tolerance=0.05, Voltage Rating="50 V"
C13 C14: library part CMP-0011178-2, "CAP, AL, 150 uF, 50 V, +/- 20%, 0.18 ohm, AEC-Q200 Grade 2, SMD", Alternate Manufacturer="Wurth Elektronik", Alternate PartNumber=865080657017, Cap_Case=G, Manufacturer=Panasonic, Supplier Part Number 1=PCE3810CT-ND, Tolerance_%=20%, Value1="0.18 ohm", Value2=50V, ValueDisplayed=150uF
C20: library part CMP-0097305-1, "4.7 µF ±20% 10V Ceramic Capacitor X5R 0603 (1608 Metric)", Digikey Part Number=732-7909-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012106012, Operating Temperature Range="-55°C to +85°C", TempCo=15%, Temperature Characteristic=X5R, Tolerance_%=20%, ValueDisplayed=4.7uF
C22 C24: library part CMP-0097306-1, "33 pF ±5% 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric)", Digikey Part Number=732-7472-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012005058, Operating Temperature Range="-55°C to +125°C", TempCo=30ppm/°C, Temperature Characteristic=NP0, Tolerance_%=5%, ValueDisplayed=33pF
C23 C41 C59: library part CMP-0097311-1, "1000 pF ±5% 100V Ceramic Capacitor C0G, NP0 0603 (1608 Metric)", Digikey Part Number=732-12187-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012006085, Operating Temperature Range="-55°C to +125°C", TempCo=30ppm/°C, Temperature Characteristic=NP0, Tolerance_%=5%, ValueDisplayed=1nF
C26 C27 C42 C43 C44 C45: library part CMP-0006215-2, "CAP, CERM, 10 pF, 50 V, +/- 5%, C0G/NP0, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7469-1-ND, TempCo=C0G/NP0, Tolerance_%=5%, Value1=Unknown, Value2=50V, ValueDisplayed=10pF
C28 C30 C47: library part CMP-0006830-4, "CAP, CERM, 0.22 uF, 16 V, +/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", Supplier Part Number 1=710-885012206048, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=0.22uF
C29 C49: library part CMP-0097608-1, "0.47 µF ±10% 16V Ceramic Capacitor X7R 0603 (1608 Metric)", Digikey Part Number=732-7969-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012206050, Operating Temperature Range="-55°C to +125°C", TempCo=15%, Temperature Characteristic=X7R, Tolerance_%=10%, ValueDisplayed=470nF
C31 C51: library part CMP-0097340-1, "Alum. Polymer Cap 10µF 10V 5.5mmV-Chip WCAP-PSLP Series Lifetime 2000h +105°C", Digikey Part Number=732-6401-1-ND, Leakage Current=300uA, Manufacturer="Wurth Electronics", Mouser Part Number=710-875105240001, Operating Temperature Range="-55°C to +105°C", Tolerance_%=20%, ValueDisplayed=10uF
C35 C40: library part CMP-0006831-4, "CAP, CERM, 1 uF, 16 V, +/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", Supplier Part Number 1=710-885012206052, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=1uF
C37 C39: library part CMP-0006828-4, "CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7959-1-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=0.01uF
C38: library part CMP-0006825-5, "CAP, CERM, 2.2 uF, 16 V, +/- 20%, X5R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7915-1-ND, TempCo=X5R, Tolerance_%=20%, Value1=Unknown, Value2=16V, ValueDisplayed=2.2uF
C55 C56: library part CMP-0079993-1, "CAP, CERM, 0.01 µF, 100 V,+/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", Supplier Part Number 1=45AC8565, TempCo=X7R, Tolerance_%=10%, Value2=100V, ValueDisplayed=0.01µF
D1: library part CMP-0002893-1, "LED, Super Red, SMD", Color="super red", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-4979-1-ND, Value1=W, Value2=1.9V
D2: library part CMP-0002894-2, "LED, Green, SMD", Color=green, Manufacturer="Wurth Elektronik", Value1=W, Value2=2V
D3: library part CMP-1426-00010-2, "LED RED CLEAR 0805 SMD", Case Code (Imperial)=0805, Case Code (Metric)=2012, Color=Red, Forward Current=30mA, Forward Voltage=1.9V, Lens Color=Colorless, Max Operating Temperature=85°C, Min Operating Temperature=-40°C, Package Quantity=1, Test Current=20mA
D5 D6 D8 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19: library part CMP-1426-00009-1, "SMD mono-color Chip LED, WL-SMCW, Bright Green", Color="Bright Green", Manufacturer="Wuerth Elektronik"
D20: library part CMP-0077592-3, "Diode, Zener, 2.7 V, 500 mW, SOD-123", Manufacturer=Vishay-Semiconductor, Power_W=500mW, Value1=0.5W
F1: library part CMP-0084439-1, "Fuse, 3 A, 32VAC/VDC, SMD", Irating_A=3A, Manufacturer=Littelfuse
FID1 FID2 FID3: library part CMP-0077181-1, "Fiducial mark.  There is nothing to buy or mount.", Manufacturer=N/A
J1 J2 J14 J15 J16 J17 J20 J21 J22 J23 J26 J27 J28 J29: library part CMP-0075483-1, "Header, 100mil, 2x1, Gold, TH", Manufacturer=Samtec, Supplier Part Number 1=SAM8736-ND
J4 J5 J18 J19 J24 J25: library part CMP-0086377-1, "Conn; Term Blk; PCB; Screw; 4; 5.08 mm; Front; 24-14 AWG; 16 A; 250 V; Solder", Current_A=16A, Manufacturer="Phoenix Contact", Voltage_V=400V
J6: library part CMP-0054796-4, "Header, 2.54 mm, 3x1, Gold, TH", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-5316-ND
J7: library part CMP-0054623-2, "Header, 2.54mm, 10x2, Tin, TH", Color=Black, Current_A=3A, Manufacturer="Sullins Connector Solutions", Supplier Part Number 1=S2012E-10-ND
J8: library part CMP-0093233-2, "2 Position Wire to Board Terminal Block Horizontal with Board 0.250\" (6.35mm) Through Hole", Current_A=32A, Digikey Part Number=732-691250610002-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-691250610002, Operating Temperature Range="-32°C to +120°C", Voltage_V=450V
J9 J10: library part CMP-0086014-1, "Header, 2.54mm, 7x2, Gold, TH", Color=Black, Current_A=3A, Manufacturer="Wurth Elektronik", Voltage_V=250V
J11: library part CMP-0097752-1, "Conn Micro USB 2.0 Type AB RCP 5 POS 0.65mm Solder RA SMD 5 Terminal 1 Port T/R", Current_A=1A, Digikey Part Number=732-5961-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-629105150921, Operating Temperature Range="-40°C to +85°C", Voltage_V=30V
J12 J13: library part CMP-1502-03256-1, "Series 101 - 5.00 mm Horizontal Entry Modular with Pressure Clamp WR-TBL, 2 pin", Manufacturer="Wurth Elektronik", Operating Temperature=-40to105degC
L1 L2: library part CMP-0003184-2, "Ferrite Bead, 140 ohm @ 100 MHz, 0.55 A, 0603", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-4663-1-ND, Value1="0.2 ohm", Value2=0.55A, ValueDisplayed="140 ohm"
L3: library part CMP-0063986-1, "Inductor, Shielded Drum Core, Ferrite, 1 uH, 24 A, 0.0012 ohm, SMD", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-2138-1-ND, Value1="0.0012 ohm", Value2=24A, ValueDisplayed=1uH
LBL1: library part CMP-0003625-1, "Thermal Transfer Printable Labels, 0.650\" W x 0.200\" H - 10,000 per roll", Manufacturer=Brady, Supplier Part Number 1=97C5133
LBL2: library part CMP-00007-1, "Harsh Environment Multi-Purpose Polyester Labels for 3\" Core Printers - 0.375\" x 0.375\", White", Manufacturer=Brady, PartNumber=THT-14-423-10, Supplier Part Number 1=97C5133
Logo1: library part CMP-0074844-1
Logo2: library part CMP-0074838-1, "Texas Instrument Corporate Signature"
Logo4: library part CMP-0074769-3, Manufacturer="Texas Instruments"
Logo5: library part CMP-0074836-1, "IEC 61010-1 Caution Warning"
LOGO6: library part CMP-0074837-2, "IEC 61010-1 Hot Surface Warning", Manufacturer="Texas Instruments"
R1: library part CMP-0095262-1, "100 Ohms ±5% 0.2W, 1/5W Chip Resistor 0603 (1608 Metric) Automotive AEC-Q200, Moisture Resistant, Pulse Withstanding Thick Film", Digikey Part Number=2019-SG73S1JTTD101JCT-ND, Manufacturer="KOA Speer", Mouser Part Number=660-SG73S1JTTD101J, Operating Temperature Range="-55°C to +155°C", Power_W=200mW, TempCo=100ppm/°C, Tolerance_%=5%
R3 R4 R62 R63 R68: library part CMP-0025697-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, PartNumber=CRCW06030000Z0EA, Power_W=100mW, Supplier Part Number 1=541-0.0GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000, ValueDisplayed=0
R9 R37 R64 R65 R66 R67: library part CMP-0097401-1, "Thick Film Resistors 0402 10Ω ±1% 0.125W", Manufacturer="Wurth Electronics", Operating Temperature Range="-55°C to +155°C", Power_W=125mW, TempCo=100ppm/°C, Tolerance_%=1%
R18 R19 R57: library part CMP-0026935-3, "RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-47KJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=47k0, ValueDisplayed=47k