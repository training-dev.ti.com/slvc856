# Altium PCB DRV81620-Q1EVM-061724.PcbDoc (part 4 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4586.07 x 3253 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 238 components, 136 nets, 678 pads, 298 vias.

## Via types
v1: diameter 24, hole 16, Top Layer to Bottom Layer, tented both sides, 195 vias
v2: diameter 24, hole 8, Top Layer to Bottom Layer, tented both sides, 57 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 21 vias
v4: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 16 vias
v5: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 9 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
VBAT_MON: D20.1 R97.1 R98.2 U1.97 | length 5691.3
  Top Layer w8: U1.97@547.99,2746.13 547.99,2562.01 685.25,2424.75 815.25,2424.75 v1(935,2305)
  Top Layer w10: D20.1@4500,3755.53 4527.56,3727.97 4527.56,3680 4527.56,3610 4525,3607.44 v2(4525,3560)
  Signal Layer 2 w8: v1(935,2305) 1078,2305 1271,2112 1955.03,2112 2060.45,2217.42 4097.42,2217.42 4311,2431 4311,2858 4525,3072 v2(4525,3560)
VDD: C9.1 R1.2 U5.24 | length 57.6
  Top Layer w8: U5.24@3410.75,3027.6 3456.93,3027.6 R1.2@3465,3019.53
VDD_3V3: C7.1 J1.2 R4.1
  other v1: 2544,3768 2589,3781 2544,3810 2589,3811
VM: C1.1 C2.1 C4.1 C8.2 C10.1 C14.1 C16.1 J4.1 J5.1 J14.2 J15.2 J18.1 J19.1 J20.2 J21.2 J24.1 J25.1 J26.2 J27.2 L3.2 TP41.1 U5.20 VM.1 | length 11150.9
  Top Layer w10: U5.20@3308.39,3025.83 3308.39,2981.61 v5(3310,2980)
  Bottom Layer w40: J26.2@1261,1577 1261,1573.76 1326.67,1508.09 1579.09,1508.09 1620,1549 ; J24.1@1620,1649 1620,1549 ; J20.2@1806,4193 1806,4196.24 1881.76,4272 2215,4272 2308,4365 J18.1@2308,4474.94 J18.1@2325.12,4492.07 ; J18.1@2325.13,4492.07 2428.06,4595 3058.94,4595 J25.1@3161.87,4492.07 ; J25.1@3161.88,4492.07 J25.1@3179,4474.94 3179,4294.34 J27.2@3079,4194.34 3219.34,4054 3753,4054 J15.2@3896,4197 3896,4292 J5.1@4087.47,4483.47 ; v2(3705,3436) 3744,3436 4341,4033 TP41.1@4341,4492 4328.28,4492 4311.22,4474.94 J5.1@4096,4474.94 ; J21.2@3745,1915 3745,1558 3754,1549 ; VM.1@3819,3085 3979,3085 4135,2929 4413,2929 4507,2835 4507,1849 4207,1549 3754,1549 ; 1620,1549 1644,1525 2405,1525 J4.1@2529,1649 2637,1541 2916.1,1541 3029,1653.9 J14.2@3029,1916.34 3178.66,1916.34 J19.1@3446,1649 3546,1549 3754,1549
  other v2: 3605,2936 3705,2936 3605,3036 3705,3036 3605,3136 3705,3136 3605,3236 3705,3236 3605,3336 3705,3336 3605,3436
VS: C3.1 C5.1 C6.1 C11.2 C12.1 C13.1 D6.2 F1.1 L3.1 R3.2 R97.2 TP40.1
  other v1: 2981,3786 2980.3,3820.18
  other v2: 3389,3858 3464,3858 3389,3958 3464,3958
pads on no net: FID1.1 FID2.1 FID3.1 J7.11 J7.12 J9.6 J9.10 J9.12 J9.13 J9.14 J10.11 J10.12 J11.4 LBL1.0 LBL2.0 SH-J6.0 SH-J7.0 SH-J8.0 SH-J9.0 SH-J10.0 SH-J11.0 SH-J12.0 SH-J19.0 SH-J27.0 SH-J28.0 SH-J31.0 SH-J32.0 SH-J33.0 SH-J35.0 SH-J36.0 U1.1 U1.2 U1.3 U1.4 U1.5 U1.6 U1.7 U1.8 U1.17 U1.18 U1.22 U1.23 U1.24 U1.28 U1.30 U1.31 U1.32 U1.33 U1.39 U1.40 U1.41 U1.48 U1.49 U1.58 U1.59 U1.68 U1.72 U1.73 U1.74 U1.75 U1.77 U1.78 U1.79 U1.80 U1.81 U1.82 U1.84 U1.85 U1.86 U1.92 U1.93 U1.94 U1.95 U1.98 U1.99 U1.100 U2.3 U2.4 U2.5 U2.6 U2.7 U2.8 U2.10 U2.12 U2.13 U2.18 U2.19 U2.22 U2.23 U2.24 U2.25 U2.26 U2.27 U2.28 U2.29 U2.30 U2.31 U2.32 U2.33 U2.34 U2.35 U2.36 U2.41 U2.42 U2.45 U2.46 U2.47 U2.48 U3.2 U3.6 U3.7

## Polygon pours and split planes (outlines as drawn)
GND on Bottom Layer "BOTTOM_LAYER_GND_P301" (solid, remove dead copper, pour order 301): 17.16,1448.82 4586.16,1448.82 4586.16,4687.82 17.16,4687.82
VS on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 296): 3486,3993 3535,3944 3535,3775 3479,3720 2971.5,3720 2908.5,3783 2908.5,3848 3053.5,3993
VM on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 300): 3882,2946 3882,3148 3742,3288 3742,3390 3783,3431 3869,3431 3881,3443 3883.28,3481.72 3869,3496 3611,3496 3564,3449 3564,3094 3523,3053 3302,3053 3295,3046 3295,2976 3302,2969 3496,2969 3549,2916 3852,2916
VDD_3V3 on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 297): 2439,3914 2439,2741 2661,2519 3470,2519 3518,2567 3518,2756 3483,2791 2823,2791 2682,2932 2682,3921 2645,3958 2483,3958
NetF1_2 on Bottom Layer "BOTTOM_LAYER_NETF1_2_P284" (solid, remove dead copper, pour order 284): 4009,3140.57 4009,3428 4034,3453 4517,3453 4550,3421 4550,3140 4549.43,3140.57
GND on Top Layer "TOP_LAYER_GND_P298" (solid, remove dead copper, pour order 298): 1.74,4681 4577,4681 4577,1431 -6.08,1431
VS on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 292): 3364,3793 3364,3960 3419,4015 3727,4015 3837,4126 3924,4126 4109,3941 4109,3731 4178,3662 4482,3662 4497,3647 4497,3593 4491,3587 4038,3587 3841,3784 3373,3784
VM on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 291): 3300,3056 3299,3055 3299,2976 3303,2972 3303,2635 3342,2596 3810,2596 3866,2652 3866,2970 3959,3063 3959,3565 3905,3619 3602,3619 3553,3570 3553,2720 3531,2698 3412,2698 3348,2762 3348,2921 3317,2952 3317,3054 3315,3056 3314,3056
NetF1_2 on Top Layer "TOP_LAYER_NETF1_2_P288" (solid, remove dead copper, pour order 288): 4006.93,3466.93 4068.5,3528.5 4501.5,3528.5 4550,3480 4550,3140 4549.43,3140.57 4006.93,3140.57
VDD_3V3 on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 294): 2544,3832 2532,3820 2532,3738 2547,3723 2619,3723 2628,3732 2628,3829 2625,3832
GND on Signal Layer 1 "SIGNAL_LAYER_1_GND_P184" (solid, remove dead copper, pour order 184): 15.78,4675 4577,4675 4577,1438 8,1438
GND on Signal Layer 2 "SIGNAL_LAYER_2_GND_P275" (solid, remove dead copper, pour order 275): 17.16,1448.82 4586.16,1448.82 4586.16,4687.82 17.16,4687.82

## Keep-outs
Keep-Out Layer:
  text ".Layer_Name" at 577,-858.49 h40

## Other copper
Top Layer:
  region net EZFET_USB_Shield: 958.2,4663.28 958.2,4445 1099,4445 1099,4568 1241.03,4568 1241.03,4445 1391.97,4445 1390.36,4663.28
  region net VS: 2959.3,3730.81 2931.37,3758.74 2931.37,3837.37 2938,3844 2980,3844 3019,3805 3019,3743 3006.81,3730.81 2996.7,3730.81
  region net NetR3_1: 2907.75,3827.73 2907.75,3784.25 2922,3770 2922,3749.19 2913.19,3740.38 2869.94,3740.38 2863.02,3747.3 2863.02,3827.02 2874,3838 2897.48,3838
  region net VDD_3V3: 2617.54,3721.8 2548.2,3721.8 2527,3743 2527,3815 2538.73,3826.73 2637.63,3826.73 2637.63,3790.13 2628,3780.5 2628,3732 2627.75,3732
  region net NetR4_2: 2661.25,3784.25 2644.94,3767.94 2644.94,3748.82 2653.38,3740.38 2702.59,3740.38 2712,3749.78 2712,3826 2701,3837 2668,3837 2661.25,3830.25
  region net VM: 3307.98,2967.02 3308.5,2875.5 3313,2871 3343,2871 3346,2874 3346,2921 3318,2949 3318,3054 3316,3056 3299,3056 3298,3055 3298,2977
  region net VDD: 3401,3055 3401,2996 3407,2990 3475,2990 3496,3011 3496,3083 3492,3087 3476,3087 3446,3057 3403,3057
  text ".Layer_Name" at 577,-858.49 h40
Signal Layer 1:
  text ".Layer_Name" at 413,-855.49 h40
Signal Layer 2:
  text ".Layer_Name" at 424,-851.49 h40
Bottom Layer:
  region net EZFET_USB_Shield: 1395.47,4456.36 958.2,4456.36 958.2,4663.28 1395.47,4663.28
  text ".Layer_Name" at 577,-858.49 h40

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  lines w5: 83.84,3156.02 97.4,3171.76 ; 314.4,2961.57 350.15,2932.83 ; 783,4362 898,4387 ; 1393,1869 1423,1869 1408,1869 ; 1408,1859 1408,1869 ; 1408,1899 1408,1884 1393,1884 ; 1412,1850.69 1424.54,1838.16 ; 1414.11,1649.86 1432.33,1662.31 ; 1414.54,1838.16 1424.54,1838.16 ; 1424.54,1848.16 1424.54,1838.16 ; 1429.27,1862.42 1440.54,1851.16 ; 1430.54,1851.16 1440.54,1851.16 ; 1440.54,1861.16 1440.54,1851.16 ; 1594,4342 1566,4342 1566,4279.56 1470.67,4279.56 1470.67,4050.56 1695,4050.56 1695,4279.56 1695,4292 ; 1756.21,4114.92 1773.39,4131.32 ; 1833.13,4108.68 1872.56,4130.15 ; 1839.45,3959.71 1866.81,3970.02 ; 2143.49,4129.04 2189.58,4110.61 ; 2177.71,3970.52 2191.54,3959.07 ; 2248.91,4133.08 2271.38,4120.98 ; 2354,1983 2414,2018 ; 2394,2169 2421,2167 ; 2468,1978 2480,1993 ; 2597.88,1979.4 2605.28,1974.12 ; 2630.21,4114.92 2647.39,4131.32 ; 2656.64,2172.92 2677.3,2165.91 ; 2672.8,2010.89 2719.82,1981.04 ; 2707.13,4108.68 2746.56,4130.15 ; 2708,3957.43 2735.36,3967.74 ; 2937,1983 3001,2018 ; 2974.92,2170.56 3000.92,2173.56 ; 3017.49,4129.04 3063.58,4110.61 ; 3049.08,3973.67 3065.93,3959.36 ; 3054.35,1976.07 3069.62,1986.24 ; 3122.91,4133.08 3145.38,4120.98 ; 3490.14,4112.7 3506.73,4098.23 ; 3562.91,4101.63 3585.89,4128.87 ; 3625,1978 3664,2001 ; 3653.13,2145.57 3668.97,2154.78 ; 3874,1981 3916,2000 ; 3905.12,2145.32 3919.83,2147.16 ; 4052.84,4146.41 4057.42,4141.06 ; 4096.98,1922.74 4107.49,1905.58 ; 4105.79,4109.81 4147.55,4125.87 ; 4114.43,2401.64 4143.6,2421.71 ; 4166,1697 4231,1697 4231,1768.81 4255.26,1768.81 4431,1768.81 4431,1515 4168,1515 ; 4175,1914 4210.23,1951.9 ; 4199.65,2493.07 4209.95,2517.45 ; 4210,4306 4334.69,4306 4334.69,4170 4559.03,4170 4559.03,4399 4334.69,4399 4212,4399 ; 1393,1884 1408,1869 ; 1393,1884 1423,1884 1408,1869 ; 1393,1884 1408,1869 ; 2269.69,3679 2269.69,3908 2494.03,3908 2494.03,3679 2269.69,3679 ; 2327,4216 2394,4217 2361,4250 2327,4216 ; 3113.69,2203 3113.69,2439 3365.69,2439 3365.69,2203 3113.69,2203
  lines w6: 314.7,3065.96 1006.79,3065.96 1006.79,3255.27 314.7,3255.27 314.7,3065.96
  lines w10: 2208.7,3605 2361.36,3606.36 ; 2214.09,2927.5 2368.75,2926.25 ; 2215.56,3475 2360,3475 ; 2219.15,3345 2355.12,3345 ; 2221.84,2795 2386.18,2795 ; 2224.15,3075 2367.06,3075 ; 1583,1933.06 1583,2451 2258,2451 2258,1933.06 1583,1933.06 ; 3102.41,2950 3597.56,2950 3597.56,3450.01 3102.41,3450.01 3102.41,2950
  text "VM" at 4314,4571 h35
  text "GND" at 4388.08,4183.45 h35 r90
  text "OUT2_S" at 4442.02,4183.45 h35 r90
  text "OUT2_D" at 4495.5,4183.45 h35 r90
  text "VM" at 4545.38,4183.45 h35 r90
  text "GND" at 2416.53,4124.32 h35
  text "OUT2_D" at 3892.32,4097.17 h35
  text "VM" at 3881,4069.95 h35 r90
  text "GND" at 1524.05,4064 h35 r90
  text "OUT6_S" at 1577.99,4064 h35 r90
  text "OUT6_D" at 1631.47,4064 h35 r90
  text "VM" at 1681.35,4064 h35 r90
  text "OUT2_S" at 3436,4051.83 h35
  text "VM" at 3163,4050.95 h35 r90
  text "VM" at 1766,4045 h35 r90
  text "GND" at 3718,4030 h35 r90
  text "GND" at 2289,4021 h35 r90
  text "GND" at 2637.99,4013.74 h35 r90
  text "OUT6_D" at 1822.17,3923 h35 r90
  text "J25" at 2335.38,3921.79 h35
  text "OUT4_S" at 2692.78,3921.55 h35 r90
  text "OUT6_S" at 2237.17,3911 h35 r90
  text "OUT4_D" at 3111.17,3911 h35 r90
  text "1" at 360,3875 h25
  text "GND" at 2146,3843 h35
  text "GND" at 1742,3830 h35
  text "GND" at 2323.08,3692.45 h35 r90
  text "OUT4_S" at 2377.02,3692.45 h35 r90
  text "OUT4_D" at 2430.5,3692.45 h35 r90
  text "VM" at 2480.38,3692.45 h35 r90
  text "VS" at 3108,3680 h35
  text "nSCS" at 2255,3620 h35
  text "GND" at 1268,3611 h35
  text "RST" at 1272.52,3536.47 h35
  text "SCLK" at 2250,3495 h35
  text "DRV81620-Q1" at 3123.76,3394.54 h33
  text "SDI" at 2255,3365 h35
  text "GND" at 97,3350 h35 r90
  text "SDO" at 2255,3230 h35
  text "PUSH" at 1118.91,3162.9 h25
  text "RST" at 1374.76,3160.38 h25
  text "nSLEEP" at 2241,3091 h35
  text "EZFET_VCC" at 76.17,3010 h35 r90
  text "MCU_3V3" at 107,2976.83 h35
  text "IN1" at 2255,2946 h35
  text "GND" at 4312,2831 h35
  text "IN0" at 2255,2810 h35
  text "VDD_3V3" at 3169,2736.83 h35
  text "3V3" at 2245,2654 h35
  text "GND" at 2464,2518 h35
  text "GND" at 2245,2505 h35
  text "CHANNEL STATUS" at 1627,2401 h35
  text "GND" at 2879,2379 h35
  text "DRV81620-Q1" at 2498,2339 h35
  text "MD088A" at 3496,2307 h60
  text "J4" at 3100.36,2303.72 h35 r90
  text "OUT0_HS" at 4189.17,2282 h35 r90
  text "VM" at 3159.69,2217 h35 r90
  text "OUT5_D" at 3218.86,2217 h35 r90
  text "OUT5_S" at 3281.86,2217 h35 r90
  text "GND" at 3338.69,2217 h35 r90
  text "CH6" at 1656.61,2170.09 h20
  text "CH4" at 1798.42,2168.36 h20
  text "CH2" at 1932.79,2168.36 h20
  text "CH0" at 2073.42,2168.36 h20
  text "GND" at 4114,2149 h35
  text "OUT7_D" at 1525.17,2095 h35 r90
  text "OUT3_S" at 3716.17,2000 h35 r90
  text "OUT7_S" at 2469.17,1998 h35 r90
  text "OUT5_D" at 3047.68,1996 h35 r90
  text "VM" at 3100,1996 h35 r90
  text "GND" at 2523,1992 h35 r90
  text "OUT5_S" at 2645.17,1989 h35 r90
  text "GND" at 2596,1985 h35 r90
  text "GND" at 3504,1985 h35 r90
  text "VM" at 3767,1981 h35 r90
  text "OUT3_D" at 3964.38,1977.32 h35 r90
  text "CH7" at 1633,1976 h20 r90
  text "GND" at 3189,1975 h35
  text "CH1" at 2138,1961 h20 r90
  text "CH3" at 2002,1952 h20 r90
  text "CH5" at 1795,1950 h20 r90
  text "VM" at 1565,1867 h35
  text "OUT7_S" at 1965,1862.83 h35
  text "OUT7_D" at 1710,1861.83 h35
  text "OUT1_HS" at 4083.14,1854.73 h35
  text "OUT7_D" at 1479.17,1708 h35 r90
  text "GND" at 2390,1682 h35 r90
  text "FAULT_STATUS" at 1300.17,1670 h35 r90
  text "MCU_3V3" at 330.34,1608 h40 r90
  text "MCU_STATUS" at 670.34,1608 h40 r90
  text "GUI_STATUS" at 965.34,1604.66 h40 r90
  text "DRV_STATUS" at 1115.34,1598 h40 r90
  text "VM" at 4224,1551 h35 r90
  text "OUT3_D" at 4283.17,1551 h35 r90
  text "OUT3_S" at 4346.17,1551 h35 r90
  text "GND" at 4403,1551 h35 r90
  text "VM" at 1197,1546 h35 r90
  text ".Layer_Name" at 577,-858.49 h40
Bottom Overlay:
  drawing of 2310 lines, arcs and shapes, not listed
  text "OUT4_S" at 2841,4387.83 h35
  text "OUT4_D" at 3077,4387.83 h35
  text "OUT2_S" at 3768,4383.83 h35
  text "OUT2_D" at 3999,4383.83 h35
  text "OUT6_S" at 1986,4380.83 h35
  text "OUT6_D" at 2212,4377.83 h35
  text "VM" at 2289,4357 h35 r270
  text "VM" at 3150,4351 h35 r270
  text "VM" at 4071,4347 h35 r270
  text "GND" at 3475,4332 h35 r270
  text "GND" at 1684,4324 h35 r270
  text "GND" at 2555,4321 h35 r270
  text "OUT2_D" at 4187,4099.83 h35
  text "GND" at 2498,4092 h35
  text "VM" at 3062,4088 h35 r270
  text "OUT2_S" at 3610,4087.83 h35
  text "VM" at 3880,4087 h35 r270
  text "VM" at 1785,4084 h35 r270
  text "GND" at 3677,4054 h35 r270
  text "GND" at 2663.22,4047.94 h35 r270
  text "GND" at 2199,4038 h35 r270
  text "OUT6_D" at 1964,4014 h35 r270
  text "OUT6_S" at 2017.83,4014 h35 r270
  text "OUT4_D" at 2890.17,4009.6 h35 r270
  text "OUT4_S" at 2839.06,4007.03 h35 r270
  text "GND" at 4334,2699 h35
  text "OUT0_HS" at 4347,2492.83 h35
  text "305-PD-24-0646" at 2231.73,2242.68 h60
  text "GND" at 4357,2180 h35
  text "JUN 2024" at 2228.23,2141.18 h60
  text "OUT7_D" at 1573.14,2068.49 h35
  text "GND" at 3278,2007 h35
  text "GND" at 3462,1977 h35 r270
  text "VM" at 3012,1967 h35 r270
  text "OUT3_D" at 3985,1965.83 h35
  text "OUT3_S" at 3649.83,1964 h35 r270
  text "GND" at 2429,1963 h35 r270
  text "GND" at 2608,1963 h35 r270
  text "VM" at 3707,1963 h35 r270
  text "OUT1_HS" at 4357,1922.83 h35
  text "OUT7_S" at 2250.83,1898 h35 r270
  text "OUT5_D" at 2832.83,1878 h35 r270
  text "OUT5_S" at 2780.83,1877 h35 r270
  text "VM" at 2514,1720 h35 r270
  text "OUT5_D" at 2811,1719.83 h35
  text "OUT5_S" at 3043,1719.83 h35
  text "VM" at 1605,1717 h35 r270
  text "VM" at 3421,1717 h35 r270
  text "GND" at 4034,1716 h35 r270
  text "OUT3_S" at 3928,1713.83 h35
  text "OUT3_D" at 3643.83,1708 h35 r270
  text "OUT7_D" at 1808.83,1706 h35 r270
  text "GND" at 2202,1706 h35 r270
  text "GND" at 3124,1704 h35 r270
  text "OUT7_S" at 2000.83,1702 h35 r270
  text "OUT7_D" at 1382.49,1640.86 h35 r270
  text "VM" at 1286.62,1634.82 h35 r270
  text ".Layer_Name" at 577,-858.49 h40
Top Paste:
  text ".Layer_Name" at 577,-858.49 h40
Bottom Paste:
  text ".Layer_Name" at 577,-858.49 h40
Top Solder:
  text ".Layer_Name" at 577,-858.49 h40
  text ".Layer_Name" at 577,-858.49 h40
Bottom Solder:
  text ".Layer_Name" at 577,-858.49 h40
Drill Guide:
  text ".Layer_Name" at 577,-858.49 h40
M1 Board Outline:
  the board outline again, w10
  text ".Layer_Name" at 577,-858.49 h40
M2 Board Dimensions:
  rectangle: 0,-275 125,-150
  rectangle: 125,-400 500,-275
  lines w7: 0,-275 1000,-275 ; 125,-400 125,-150 ; 250,-400 250,-150 ; 500,-400 500,-150 ; 750,-400 750,-150 ; 0,-400 1000,-400 1000,-150 0,-150 0,-400
  text ".Layer_Name" at 577,-858.49 h40
M3 3D STEP Top:
  text ".Layer_Name" at 577,-858.49 h40
M4 3D STEP Bottom:
  text ".Layer_Name" at 577,-858.49 h40
M5 Assembly Top:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 1153.5,-318.5 h40
  text "ASSEMBLY VARIANT:" at 1153,-434 h40
  text ".VariantName" at 2189,-434 h40
  text "PCB VIEWED FROM TOP SIDE" at -228.5,-655.67 h40
  text "BOARD #:" at 2248,-655.67 h40
  text ".PRJ_Number" at 2793.5,-655.67 h40
  text "REV:" at 3638,-655.67 h40
  text ".PCB_Rev" at 3929.5,-655.67 h40
  text "SVN REV:" at 4476,-655.67 h40
  text ".VersionControl_RevNumber" at 4982,-655.67 h40
  text "TID #:" at 2248,-859 h40
  text ".TID" at 2793.5,-859 h40
  text "PLOT NAME =" at -228.5,-1064.34 h40
  text ".plot_File_Name" at 577,-1064.34 h40
  text "GENERATED    :" at 2250,-1064.34 h40
  text ".Print_Date" at 3119.5,-1064.34 h40
  text ".Print_Time" at 3848.5,-1064.34 h40
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h40
M6 Assembly Bottom:
  lines w10: -292.5,-727.33 6309.5,-727.33 ; -290.5,-930.67 6309.5,-930.67 ; 1115.5,-1140.5 1115.5,-937.67 ; 1737.5,-727.33 1737.5,-524 ; 2577.5,-727.33 2577.5,-524 ; 3844.5,-1134 3844.5,-524 ; 4733.5,-1134 6309,-1134 6309,-524 -292.5,-524 -292.5,-1134 2304.5,-1134 6309.5,-1134 6309.5,-524
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 6102,-318 h40
  text ".VariantName" at 5058,-434 h40
  text "ASSEMBLY VARIANT:" at 6097,-434 h40
  text ".VersionControl_RevNumber" at 1035.5,-656.17 h40
  text "SVN REV:" at 1541.5,-656.17 h40
  text ".PCB_Rev" at 2088,-656.17 h40
  text "REV:" at 2379.5,-656.17 h40
  text ".PRJ_Number" at 3224,-656.17 h40
  text "BOARD #:" at 3769.5,-656.17 h40
  text "PCB VIEWED FROM BOTTOM SIDE" at 6246,-656.17 h40
  text ".TID" at 3224,-859.5 h40
  text "TID #:" at 3769.5,-859.5 h40
  text "TEXAS INSTRUMENTS" at 904.5,-1064.84 h40
  text ".Print_Time" at 2169,-1064.84 h40
  text ".Print_Date" at 2898,-1064.84 h40
  text "GENERATED    :" at 3767.5,-1064.84 h40
  text ".plot_File_Name" at 5440.5,-1064.84 h40
  text "PLOT NAME =" at 6246,-1064.84 h40
M9 Title Sheet:
  drawing of 57 lines, arcs and shapes, not listed
  text "1" at 739.84,8036.5 h25
  text "2" at 3235.5,8036.5 h25
  text "3" at 5724.84,8036.5 h25
  text "4" at 8231.51,8036.5 h25
  text "5" at 10730.5,8036.5 h25
  text "6" at 13235.5,8036.5 h25
  text "A" at -416.5,6893.5 h25
  text "A" at 14383.5,6893.5 h25
  text "B" at -416.5,4513.5 h25
  text "B" at 14383.5,4513.5 h25
  text "C" at -416.5,2138.5 h25
  text "C" at 14383.5,2138.5 h25
  text "PROJECT TITLE:" at 11343.5,277.5 h55
  text "DRV81620-Q1EVM" at 11393.5,144.17 h55
  text "DESIGNED FOR:" at 11343.5,-23.5 h55
  text ".PRJ_Customer" at 11393.5,-163.5 h55
  text "D" at -416.5,-231.5 h40
  text "D" at 14383.5,-231.5 h25
  text "FILE NAME:" at 11343.5,-323.5 h55
  text ".PCB_File_Name_No_Path" at 11393.5,-443.5 h55
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 6374,-605.34 h40
  text "ENGINEER:" at 11343.5,-613.5 h55
  text "LAYOUT BY:" at 12848.5,-613.5 h55
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 6329.01,-718 h40
  text ".PRJ_Engineer" at 11391,-733 h55
  text "PACTRON" at 12896.5,-733 h55
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 6329.01,-830.67 h40
  text ".Layer_Name" at 577,-858.49 h40
  text "ALTIUM DESIGNER VERSION:" at 12848.5,-923.5 h55
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 6329.01,-943.33 h40
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 6374,-1056 h40
  text ".print_Scale" at 11393.5,-1056.83 h55
  text ".Application_BuildNumber" at 12899,-1056.83 h55
  text "1" at 739.84,-1263.5 h40
  text "2" at 3235.5,-1263.5 h40
  text "3" at 5724.84,-1263.5 h40
  text "4" at 8231.51,-1263.5 h40
  text "5" at 10730.5,-1263.5 h55
  text "6" at 13235.5,-1263.5 h55
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 12382.02,6356.17 h55
  text "MIN. TRACK WIDTH:" at 11737.46,6224.05 h55
  text "8" at 12833.7,6224.05 h55
  text "MIL" at 12988.46,6224.05 h55
  text "MIN. CLEARANCE:" at 11737.46,6099.92 h55
  text "5.9" at 12773.7,6099.93 h55
  text "MIL" at 12988.46,6099.92 h55
  text "19.68" at 12714,5979 h55
  text "MIN. VIA PAD SIZE:" at 11737.46,5975.8 h55
  text "MIL" at 12988.46,5975.8 h55
  text "0.05mm (2MIL)" at 12432.46,5845.9 h55
  text "MINIMUM ANNULAR RING" at 11408.23,5837.67 h55
  text "EXTERNAL" at 13140.46,5837.67 h55
  text "PER" at 11608.23,5727.55 h55
  text "IPC-D-275 CLASS 2 LEVEL C" at 11828.23,5727.54 h55
  text "MIL, HOLES" at 13316.46,5627.07 h55
  text "+/-" at 12924,5618.48 h55
  text "+/-" at 13778,5618.48 h55
  text "REGISTRATION TOLERANCES:" at 11408.23,5617.42 h55
  text "METAL" at 12608,5617.42 h55
  text "5" at 13184.2,5617.42 h55
  text "3" at 14017.2,5617.42 h55
  text "MIL" at 14133.46,5617.42 h55
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 11408.23,5519.1 h55
  text "+/-" at 13778,5516.23 h55
  text "3" at 14017.2,5515.17 h55
  text "MIL" at 14133.46,5515.17 h55
  text "MATERIAL:" at 11333.46,5377.52 h55
  text "FR-4 High Tg" at 12319.9,5249 h55
  text "X" at 12175.46,5241.01 h55
  text "FR-408" at 11754.46,5236.49 h55
  text "OTHER" at 13242.46,5236.49 h55
  text "62 MIL (1.6mm) +/-10%" at 12074.56,5093.46 h55
  text "X" at 11954.46,5091.01 h55
  text "THICKNESS:" at 11408.23,5085.24 h55
  text "OTHER" at 13359.46,5085.24 h55
  text "TOLERANCE:" at 11408.23,4946.92 h55
  text "X" at 12256.46,4946.92 h55
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4946.92 h55
  text "OTHER +/-" at 12434.46,4802.73 h55
  text "BOW & TWIST:" at 11408.23,4657.54 h55
  text "X" at 12256.46,4657.54 h55
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4657.54 h55
  text "OTHER +/-" at 12434.46,4510.85 h55
  text "DRILLING:" at 11333.46,4380.23 h55
  text "NC_DRILL FILES" at 13094.46,4275.04 h55
  text "REFERENCE:" at 11408.23,4271.1 h55
  text "X" at 12065.46,4271.01 h55
  text "AS SHOWN" at 12243.46,4271.1 h55
  text "X" at 12966.46,4271.1 h55
  text "FAB NOTES:" at 5656.93,4136.41 h55
  text "OTHER" at 13392.46,4128.85 h55
  text "PTH COPPER THICKNESS:" at 11407.91,4125.32 h55
  text "X" at 12547.14,4125.32 h55
  text "20-30 um" at 12675.14,4125.32 h55
  text "1. NO VENDOR LOGO OR NAME ON THE BOARD." at 5655.93,4009.72 h55
  text "BOARD FINISH:" at 11333.46,3977.73 h55
  text "2. ALL HOLES SHOULD BE FHS." at 5655.93,3887.09 h55
  text "SILKSCREEN:" at 11488.68,3867.6 h55
  text "X" at 12446.46,3867.6 h55
  text "TOP" at 12563.46,3867.6 h55
  text "X" at 12956.46,3867.6 h55
  text "BOTTOM" at 13074.46,3867.6 h55
  text "3. CLIP SILK ON NO MASK AREA." at 5659.93,3766.89 h55
  text "SILKSCREEN COLOR:" at 11488.68,3712.41 h55
  text "X" at 12445.46,3712.41 h55
  text "WHITE" at 12563.46,3712.41 h55
  text "OTHER" at 13074.46,3712.41 h55
  text "4. 7.87MIL DRILLS NEED TO BE NON-CONDUCTIVE SOLDER MASK PLUGGING FROM BOTTOM SIDE" at 5658,3679 h55
  text "5.REMOVE NON-FUNCTIONAL PADS IN INNER LAYER ." at 5661,3583 h55
  text "X" at 12576.46,3568.96 h55
  text "GREEN" at 12694.46,3568.96 h55
  text "OTHER" at 13312.46,3568.96 h55
  text "SOLDER RESIST COLOR:" at 11488.68,3562.1 h55
  text "X" at 12576.46,3414.71 h55
  text "MATTE" at 12694.46,3414.71 h55
  text "SEMI-GLOSS" at 13312,3414.07 h55
  text "IMMERSION GOLD (ENIG)" at 12394.46,3241.94 h55
  text "ENEPIG" at 13732,3234.72 h55
  text "SURFACE FINISH:" at 11333.46,3233.72 h55
  text "X" at 12216.46,3233.72 h55
  text "IMM. TIN/SILVER OR EQUIV" at 11663,3096.4 h55
  text "OTHER" at 13094.46,3092.47 h55
  text "ARRAY/PANEL:" at 11333.46,2937.09 h55
  text "X" at 12216.46,2932.9 h55
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 12394.46,2928.87 h55
  text "N.C. ROUTE" at 12394.46,2792.9 h55
  text "V. SCORE" at 13260.46,2792.9 h55
  text "CERTIFICATION:" at 11333.46,2663.77 h55
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 12058.46,2663.77 h55
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 12058.46,2569.71 h55
  text "X" at 11695.97,2441.08 h55
  text "ANSI IPC-A-600F CLASS ->" at 11823.96,2441.08 h55
  text "X" at 13471.97,2441.08 h55
  text "2" at 13581.96,2441.08 h55
  text "1" at 13266.96,2439.58 h55
  text "3" at 13935.96,2439.58 h55
  text "X" at 12507.97,2293.39 h55
  text "RoHS" at 12635.96,2293.39 h55
  text "OTHER" at 13280.36,2293.39 h55
  text "PER ORDER" at 13677.42,2293.39 h55
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 11361,2139.57 h55
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 11361,2023.5 h55
  text "ADDITIONAL REQUIREMENTS:" at 11333.46,1854.08 h55
  text "MICROSECTION:" at 11408.23,1746.95 h55
  text "YES" at 12313.96,1746.95 h55
  text "REQUIRED" at 13175.46,1602.62 h55
  text "BARE BOARD ELEC. TEST:" at 11408.23,1599.76 h55
  text "NONE" at 12713.96,1599.76 h55
  text "X" at 13057.46,1599.76 h55
  text "PER ORDER" at 13767.46,1599.76 h55
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 11576.38,1394.82 h55
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 11584.38,1290.84 h55
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 11583.39,1127.46 h55
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 11575.39,891.74 h55
  text ".Layer_Name" at 577,-858.49 h40
M11 Gerber Information:
  circle w10: c18.9,1247 r87.29
  circle w10: c18.8,1247.1 r42.65
  circle w10: c4791.9,1247 r87.29
  circle w10: c4791.8,1247.1 r42.65
  circle w10: c4790.9,4888 r87.29
  circle w10: c4790.8,4888.1 r42.65
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; -113.6,1247.9 18,1247.9 ; 18,1116.3 18,1247.9 ; 18,1379.5 18,1247.9 ; 149.6,1247.9 18,1247.9 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4658.4,4888.9 4790,4888.9 ; 4659.4,1247.9 4791,1247.9 ; 4790,4757.3 4790,4888.9 ; 4790,5020.5 4790,4888.9 ; 4791,1116.3 4791,1247.9 ; 4791,1379.5 4791,1247.9 ; 4902,-1140 4902,-937.17 ; 4921.6,4888.9 4790,4888.9 ; 4922.6,1247.9 4791,1247.9
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -228.5,-655.67 h40
  text "BOARD #:" at 2248,-655.67 h40
  text "DRV81620-Q1EVM" at 2793.5,-655.67 h40
  text "REV:" at 3638,-655.67 h40
  text ".PCB_Rev" at 3929.5,-655.67 h40
  text "SVN REV:" at 4476,-655.67 h40
  text ".VersionControl_RevNumber" at 4982,-655.67 h40
  text "LAYER NAME =" at -228.5,-858.49 h40
  text "TID #:" at 2248,-859 h40
  text ".TID" at 2793.5,-859 h40
  text "PLOT NAME =" at -228.5,-1064.34 h40
  text ".plot_File_Name" at 577,-1064.34 h40
  text "GENERATED    :" at 2250,-1064.34 h40
  text ".Print_Date" at 3119.5,-1064.34 h40
  text ".Print_Time" at 3848.5,-1064.34 h40
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h40
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Stackup:" at 4956,5953.33 h70
  text "Layer" at 4988.19,5878.6 h26.6
  text "Name" at 5171.07,5878.6 h26.6
  text "Material" at 5588.89,5878.6 h26.6
  text "Thickness" at 5971.25,5878.6 h26.6
  text "Constant" at 6260.52,5878.6 h26.6
  text "Board Layer Stack" at 6514.33,5878.6 h26.6
  text "Top Overlay" at 5171.07,5825.39 h26.6
  text "Top Solder" at 5171.07,5772.18 h26.6
  text "Solder Resist" at 5588.89,5772.18 h26.6
  text "0.40mil" at 5971.25,5772.18 h26.6
  text "3.5" at 6260.52,5772.18 h26.6
  text "1" at 4988.19,5718.97 h26.6
  text "Top Layer" at 5171.07,5718.97 h26.6
  text "2.80mil" at 5971.25,5718.97 h26.6
  text "Dielectric 1" at 5171.07,5665.76 h26.6
  text "FR-4 High Tg" at 5588.89,5665.76 h26.6
  text "11.40mil" at 5971.25,5665.76 h26.6
  text "4.2" at 6260.52,5665.76 h26.6
  text "2" at 4988.19,5612.56 h26.6
  text "Signal Layer 1" at 5171.07,5612.56 h26.6
  text "1.40mil" at 5971.25,5612.56 h26.6
  text "Dielectric 2" at 5171.07,5559.35 h26.6
  text "FR-4 High Tg" at 5588.89,5559.35 h26.6
  text "30.00mil" at 5971.25,5559.35 h26.6
  text "4.2" at 6260.52,5559.35 h26.6
  text "3" at 4988.19,5506.14 h26.6
  text "Signal Layer 2" at 5171.07,5506.14 h26.6
  text "1.40mil" at 5971.25,5506.14 h26.6
  text "Dielectric 3" at 5171.07,5452.93 h26.6
  text "FR-4 High Tg" at 5588.89,5452.93 h26.6
  text "11.40mil" at 5971.25,5452.93 h26.6
  text "4.2" at 6260.52,5452.93 h26.6
  text "4" at 4988.19,5399.72 h26.6
  text "Bottom Layer" at 5171.07,5399.72 h26.6
  text "2.80mil" at 5971.25,5399.72 h26.6
  text "Bottom Solder" at 5171.07,5346.51 h26.6
  text "Solder Resist" at 5588.89,5346.51 h26.6
  text "0.40mil" at 5971.25,5346.51 h26.6
  text "3.5" at 6260.52,5346.51 h26.6
  text "Bottom Overlay" at 5171.07,5293.31 h26.6
  text ".Layer_Name" at 577,-858.49 h40
M13 Component Bodies Top:
  text ".Layer_Name" at 577,-858.49 h40
M14 Component Bodies Bottom:
  text ".Layer_Name" at 577,-858.49 h40
M15 Courtyards Top:
  text ".Layer_Name" at 577,-858.49 h40
M16 Courtyards Bottom:
  text ".Layer_Name" at 577,-858.49 h40
Drill Drawing:
  drawing of 180 lines, arcs and shapes, not listed
  text "Drill Drawing :" at 4555,7365.99 h60
  text "Symbol" at 4567.15,7242.59 h30.78
  text "Quantity" at 4785.75,7242.59 h30.78
  text "Finished Hole Size" at 5060.76,7242.59 h30.78
  text "Plated" at 5638.36,7242.59 h30.78
  text "Hole Type" at 5856.96,7242.59 h30.78
  text "Drill Layer Pair" at 6173,7242.59 h30.78
  text "Hole Tolearance" at 6815.55,7242.59 h30.78
  text "Routed Path Length" at 7311.1,7242.59 h30.78
  text "Hole Length" at 7893.83,7242.59 h30.78
  text "37" at 4785.75,7178.46 h25.65
  text "7.87mil (0.200mm)" at 5060.76,7178.46 h25.65
  text "PTH" at 5638.36,7178.46 h25.65
  text "Round" at 5856.96,7178.46 h25.65
  text "Top Layer - Bottom Layer" at 6173,7178.46 h25.65
  text "+3mil/-3mil" at 6815.55,7178.46 h25.65
  text "-" at 7311.1,7178.46 h25.65
  text "-" at 7893.83,7178.46 h25.65
  text "57" at 4785.75,7114.33 h25.65
  text "8.00mil (0.203mm)" at 5060.76,7114.33 h25.65
  text "PTH" at 5638.36,7114.33 h25.65
  text "Round" at 5856.96,7114.33 h25.65
  text "Top Layer - Bottom Layer" at 6173,7114.33 h25.65
  text "+3mil/-3mil" at 6815.55,7114.33 h25.65
  text "-" at 7311.1,7114.33 h25.65
  text "-" at 7893.83,7114.33 h25.65
  text "9" at 4785.75,7050.2 h25.65
  text "10.00mil (0.254mm)" at 5060.76,7050.2 h25.65
  text "PTH" at 5638.36,7050.2 h25.65
  text "Round" at 5856.96,7050.2 h25.65
  text "Top Layer - Bottom Layer" at 6173,7050.2 h25.65
  text "+3mil/-3mil" at 6815.55,7050.2 h25.65
  text "-" at 7311.1,7050.2 h25.65
  text "-" at 7893.83,7050.2 h25.65
  text "195" at 4785.75,6986.07 h25.65
  text "16.00mil (0.406mm)" at 5060.76,6986.07 h25.65
  text "PTH" at 5638.36,6986.07 h25.65
  text "Round" at 5856.96,6986.07 h25.65
  text "Top Layer - Bottom Layer" at 6173,6986.07 h25.65
  text "+3mil/-3mil" at 6815.55,6986.07 h25.65
  text "-" at 7311.1,6986.07 h25.65
  text "-" at 7893.83,6986.07 h25.65
  text "7" at 4785.75,6921.94 h25.65
  text "17.72mil (0.450mm)" at 5060.76,6921.94 h25.65
  text "PTH" at 5638.36,6921.94 h25.65
  text "Round" at 5856.96,6921.94 h25.65
  text "Top Layer - Bottom Layer" at 6173,6921.94 h25.65
  text "+3mil/-3mil" at 6815.55,6921.94 h25.65
  text "-" at 7311.1,6921.94 h25.65
  text "-" at 7893.83,6921.94 h25.65
  text "58" at 4785.75,6857.81 h25.65
  text "40.00mil (1.016mm)" at 5060.76,6857.81 h25.65
  text "PTH" at 5638.36,6857.81 h25.65
  text "Round" at 5856.96,6857.81 h25.65
  text "Top Layer - Bottom Layer" at 6173,6857.81 h25.65
  text "+3mil/-3mil" at 6815.55,6857.81 h25.65
  text "-" at 7311.1,6857.81 h25.65
  text "-" at 7893.83,6857.81 h25.65
  text "28" at 4785.75,6793.68 h25.65
  text "43.31mil (1.100mm)" at 5060.76,6793.68 h25.65
  text "PTH" at 5638.36,6793.68 h25.65
  text "Round" at 5856.96,6793.68 h25.65
  text "Top Layer - Bottom Layer" at 6173,6793.68 h25.65
  text "+3mil/-3mil" at 6815.55,6793.68 h25.65
  text "-" at 7311.1,6793.68 h25.65
  text "-" at 7893.83,6793.68 h25.65
  text "3" at 4785.75,6729.55 h25.65
  text "45.28mil (1.150mm)" at 5060.76,6729.55 h25.65
  text "PTH" at 5638.36,6729.55 h25.65
  text "Round" at 5856.96,6729.55 h25.65
  text "Top Layer - Bottom Layer" at 6173,6729.55 h25.65
  text "+3mil/-3mil" at 6815.55,6729.55 h25.65
  text "-" at 7311.1,6729.55 h25.65
  text "-" at 7893.83,6729.55 h25.65
  text "10" at 4785.75,6665.42 h25.65
  text "51.18mil (1.300mm)" at 5060.76,6665.42 h25.65
  text "PTH" at 5638.36,6665.42 h25.65
  text "Round" at 5856.96,6665.42 h25.65
  text "Top Layer - Bottom Layer" at 6173,6665.42 h25.65
  text "+3mil/-3mil" at 6815.55,6665.42 h25.65
  text "-" at 7311.1,6665.42 h25.65
  text "-" at 7893.83,6665.42 h25.65
  text "24" at 4785.75,6601.29 h25.65
  text "54.24mil (1.378mm)" at 5060.76,6601.29 h25.65
  text "PTH" at 5638.36,6601.29 h25.65
  text "Round" at 5856.96,6601.29 h25.65
  text "Top Layer - Bottom Layer" at 6173,6601.29 h25.65
  text "+3mil/-3mil" at 6815.55,6601.29 h25.65
  text "-" at 7311.1,6601.29 h25.65
  text "-" at 7893.83,6601.29 h25.65
  text "2" at 4785.75,6537.16 h25.65
  text "59.06mil (1.500mm)" at 5060.76,6537.16 h25.65
  text "PTH" at 5638.36,6537.16 h25.65
  text "Round" at 5856.96,6537.16 h25.65
  text "Top Layer - Bottom Layer" at 6173,6537.16 h25.65
  text "+3mil/-3mil" at 6815.55,6537.16 h25.65
  text "-" at 7311.1,6537.16 h25.65
  text "-" at 7893.83,6537.16 h25.65
  text "22" at 4785.75,6473.03 h25.65
  text "63.00mil (1.600mm)" at 5060.76,6473.03 h25.65
  text "PTH" at 5638.36,6473.03 h25.65
  text "Round" at 5856.96,6473.03 h25.65
  text "Top Layer - Bottom Layer" at 6173,6473.03 h25.65
  text "+3mil/-3mil" at 6815.55,6473.03 h25.65
  text "-" at 7311.1,6473.03 h25.65
  text "-" at 7893.83,6473.03 h25.65
  text "2" at 4785.75,6408.9 h25.65
  text "25.59mil (0.650mm)" at 5060.76,6408.9 h25.65
  text "PTH" at 5638.36,6408.9 h25.65
  text "Slot" at 5856.96,6408.9 h25.65
  text "Top Layer - Bottom Layer" at 6173,6408.9 h25.65
  text "+3mil/-3mil" at 6815.55,6408.9 h25.65
  text "3.94mil (0.100mm)" at 7311.1,6408.9 h25.65
  text "29.53mil (0.750mm)" at 7893.83,6408.9 h25.65
  text "2" at 4785.75,6344.77 h25.65
  text "51.18mil (1.300mm)" at 5060.76,6344.77 h25.65
  text "PTH" at 5638.36,6344.77 h25.65
  text "Slot" at 5856.96,6344.77 h25.65
  text "Top Layer - Bottom Layer" at 6173,6344.77 h25.65
  text "+3mil/-3mil" at 6815.55,6344.77 h25.65
  text "-21.65mil (-0.550mm)" at 7311.1,6344.77 h25.65
  text "29.53mil (0.750mm)" at 7893.83,6344.77 h25.65
  text "456 Total" at 4785.75,6280.64 h25.65
  text "Slot definitions :" at 4567.15,6217.21 h25.65
  text "Routed Path Length" at 5010.69,6217.21 h25.65
  text "= Calculated from tool start centre position to tool end centre position." at 5484.14,6217.21 h25.65
  text "Hole Length" at 5010.69,6173.02 h25.65
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 5308.91,6173.02 h25.65
  text ".Layer_Name" at 577,-858.49 h40
Mechanical 17:
  text ".Layer_Name" at 577,-858.49 h40
Mechanical 18:
  text ".Layer_Name" at 577,-858.49 h40
Mechanical 19:
  text ".Layer_Name" at 577,-858.49 h40

## Dimensions
0,-400 to 1000,-400 on M2 Board Dimensions
-1,4681 to -6.07,1431 on M2 Board Dimensions
-1,4681 to 4580,4678 on M2 Board Dimensions