# Altium PCB MD091_DRV81242EVM_061924.PcbDoc (part 4 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4586.07 x 3253 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 237 components, 133 nets, 665 pads, 296 vias.

## Via types
v1: diameter 24, hole 16, Top Layer to Bottom Layer, tented both sides, 195 vias
v2: diameter 24, hole 8, Top Layer to Bottom Layer, tented both sides, 53 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 21 vias
v4: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 16 vias
v5: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 11 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
USB_D_P: J11.3 R75.1 U6.2 U6.5 U6.6 | length 462.8
  Top Layer w8: U6.6@1151.7,2932.62 U6.5@1171.39,2932.62 ; v1(1156.07,2844) 1171.23,2859.15 1171.23,2885.37 1171.39,2885.53 U6.5@1171.39,2932.62 ; J11.3@1177.89,3027 1177.89,3021.69 1172.24,3016.04 1172.24,2933.47 U6.5@1171.39,2932.62
  Top Layer w15: R75.1@1206.07,2613.68 v1(1206.07,2664)
  Signal Layer 2 w15: v1(1156.07,2844) 1156.07,2714 v1(1206.07,2664)
VBAT_MON: D20.1 R97.1 R98.2 U1.97 | length 5691.3
  Top Layer w8: U1.97@554.07,1315.13 554.07,1131 691.33,993.74 821.33,993.74 v1(941.07,874)
  Top Layer w10: D20.1@4506.07,2324.53 4533.63,2296.97 R98.2@4533.63,2249 R97.1@4533.63,2179 4531.07,2176.44 v2(4531.07,2129)
  Signal Layer 2 w8: v1(941.07,874) 1084.07,874 1277.07,681 1964.28,681 2053.28,770 3923.52,770 3969.01,815.49 4132.57,815.49 4317.07,1000 4317.07,1427 4531.07,1641 v2(4531.07,2129)
VDD: C9.1 R1.2 U5.24 | length 57.6
  Top Layer w8: U5.24@3416.82,1596.59 3463,1596.59 R1.2@3471.07,1588.52
VDD_3V3: C7.1 J4.2 R4.1
  other v1: 2550.07,2337 2595.07,2350 2550.07,2379 2595.07,2380
VM: C4.1 C8.2 C10.1 C14.1 C16.1 C17.1 C18.1 J5.1 J14.2 J15.2 J16.2 J18.1 J19.1 J21.2 L3.2 TP17.1 TP18.1 TP41.1 U5.20 VM.1 | length 5132.2
  Top Layer w10: U5.20@3314.46,1594.82 3314.46,1550.61 v5(3316.07,1549)
  Bottom Layer w40: J19.1@3452.08,218 3570.76,336.68 3687.76,336.68 3751.08,400 J21.2@3751.08,484 3751.08,711 3681,781.08 J18.1@3681,895 3682,896 3861.08,896 TP17.1@3862.07,897 3867.26,891.81 3923.26,891.81 TP18.1@4091.07,724 4379.33,724 J16.2@4424.59,769.26 4511,855.67 4511,1190.07 J14.2@4424.59,1276.47 4424.59,1366.41 4293,1498 4141.07,1498 3985.07,1654 VM.1@3825.07,1654 ; v2(3711.07,2005) 3750.07,2005 4347.07,2602 TP41.1@4347.07,3061 J5.1@4102.08,3061 3902.08,2861 J15.2@3902.08,2766
  other v2: 3611.07,1505 3711.07,1505 3611.07,1605 3711.07,1605 3611.07,1705 3711.07,1705 3611.07,1805 3711.07,1805 3611.07,1905 3711.07,1905 3611.07,2005
VM_HS: J18.2 U5.9 U5.16 VM_HS.1 | length 1868.2
  Top Layer w10: v5(3201.46,1929.32) 3201.46,1929.1 3212.1,1918.46 U5.9@3212.1,1823.17 ; v5(3212.1,1550.61) U5.16@3212.1,1594.82
  Bottom Layer w20: v5(3201.46,1929.32) 3087,1814.86 3087,1598.05 3134.44,1550.61 v5(3212.1,1550.61) 3328.71,1434 3585,1434 3654,1365 3654,1137 3581,1064 J18.2@3581,895 VM_HS.1@3410,895
VS: C3.1 C5.1 C6.1 C11.2 C12.1 C13.1 D6.2 F1.1 L3.1 R3.2 R97.2 TP40.1
  other v1: 2987.07,2355 2986.37,2389.18
  other v2: 3395.07,2427 3470.07,2427 3395.07,2527 3470.07,2527
pads on no net: FID1.1 FID2.1 FID3.1 J7.11 J7.12 J9.6 J9.10 J9.12 J9.13 J9.14 J10.11 J10.12 J11.4 LBL1.0 LBL2.0 SH-J6.0 SH-J7.0 SH-J8.0 SH-J9.0 SH-J10.0 SH-J11.0 SH-J12.0 SH-J19.0 SH-J27.0 SH-J28.0 SH-J31.0 SH-J32.0 SH-J33.0 SH-J35.0 SH-J36.0 U1.1 U1.2 U1.3 U1.4 U1.5 U1.6 U1.7 U1.8 U1.17 U1.18 U1.22 U1.23 U1.24 U1.28 U1.30 U1.31 U1.32 U1.33 U1.39 U1.40 U1.41 U1.48 U1.49 U1.58 U1.59 U1.68 U1.72 U1.73 U1.74 U1.75 U1.77 U1.78 U1.79 U1.80 U1.81 U1.82 U1.84 U1.85 U1.86 U1.92 U1.93 U1.94 U1.95 U1.98 U1.99 U1.100 U2.3 U2.4 U2.5 U2.6 U2.7 U2.8 U2.10 U2.12 U2.13 U2.18 U2.19 U2.22 U2.23 U2.24 U2.25 U2.26 U2.27 U2.28 U2.29 U2.30 U2.31 U2.32 U2.33 U2.34 U2.35 U2.36 U2.41 U2.42 U2.45 U2.46 U2.47 U2.48 U3.2 U3.6 U3.7 U5.12 U5.13

## Polygon pours and split planes (outlines as drawn)
GND on Bottom Layer "BOTTOM_LAYER_GND_P301" (solid, pour order 301): 23.23,17.81 4592.23,17.81 4592.23,3256.81 23.23,3256.81
VDD_3V3 on Bottom Layer "NONET_L-01_P-001" (solid, pour order 297): 3447.44,1360 3499.38,1308.06 3583.54,1308.06 3612.08,1279.53 3612.08,1137.51 3562.56,1088 2667.07,1088 2445.07,1310 2445.07,2483 2489.07,2527 2651.07,2527 2688.07,2490 2688.07,1501 2829.07,1360
VM on Bottom Layer "NONET_L-01_P-001" (solid, pour order 300): 3888.07,1515 3888.07,1717 3748.07,1857 3748.07,1959 3789.07,2000 3875.07,2000 3887.07,2012 3889.35,2050.72 3875.07,2065 3617.07,2065 3570.07,2018 3570.07,1663 3529.07,1622 3308.07,1622 3301.07,1615 3301.07,1545 3308.07,1538 3502.07,1538 3548.1,1491.97 3865.05,1491.97
VS on Bottom Layer "NONET_L-01_P-001" (solid, pour order 296): 3492.07,2562 3541.07,2513 3541.07,2344 3485.07,2289 2977.57,2289 2914.57,2352 2914.57,2417 3059.57,2562
NetF1_2 on Bottom Layer "BOTTOM_LAYER_NETF1_2_P284" (solid, pour order 284): 4015.07,1709.57 4015.07,1997 4040.07,2022 4523.07,2022 4556.07,1990 4556.07,1709 4555.51,1709.57
GND on Top Layer "TOP_LAYER_GND_P298" (solid, pour order 298): 21.86,3244 4583.07,3244 4583.07,7 14.07,7
VM on Top Layer "NONET_L-01_P-001" (solid, pour order 291): 3559.07,1519 3623.07,1455 3623.07,1224.28 3600.26,1201.47 3522.99,1201.47 3493.05,1231.41 3493.05,1271.42 3479.96,1284.51 3400.56,1284.51 3354.07,1331 3354.07,1490 3323.07,1521 3323.07,1623 3321.07,1625 3306.07,1625 3305.07,1624 3305.07,1545 3314.06,1536.01 3314.06,1132.28 3340.86,1105.48 3792.6,1105.48 3872.07,1184.95 3872.07,1539 3965.07,1632 3965.07,2134 3911.07,2188 3608.07,2188 3559.07,2139
NetF1_2 on Top Layer "TOP_LAYER_NETF1_2_P288" (solid, pour order 288): 4013,2035.93 4074.58,2097.5 4507.57,2097.5 4556.07,2049 4556.07,1709 4555.51,1709.57 4013,1709.57
VDD_3V3 on Top Layer "NONET_L-01_P-001" (solid, pour order 294): 2550.07,2401 2538.07,2389 2538.07,2307 2553.07,2292 2625.07,2292 2634.07,2301 2634.07,2398 2631.07,2401
VS on Top Layer "NONET_L-01_P-001" (solid, pour order 292): 3370.07,2362 3370.07,2529 3425.07,2584 3733.07,2584 3843.07,2695 3930.07,2695 4115.07,2510 4115.07,2300 4184.07,2231 4488.07,2231 4503.07,2216 4503.07,2162 4497.07,2156 4044.07,2156 3847.07,2353 3379.07,2353
GND on Signal Layer 1 "SIGNAL_LAYER_1_GND_P184" (solid, pour order 184): 21.86,3244 4583.07,3244 4583.07,7 14.07,7
GND on Signal Layer 2 "SIGNAL_LAYER_2_GND_P275" (solid, pour order 275): 23.23,17.81 4592.23,17.81 4592.23,3256.81 23.23,3256.81

## Keep-outs
Keep-Out Layer:
  text ".Layer_Name" at 583.07,-2289.5 h55

## Other copper
Top Layer:
  region net VS: 2965.37,2299.81 2937.45,2327.74 2937.45,2406.37 2944.07,2413 2986.07,2413 3025.07,2374 3025.07,2312 3012.89,2299.81 3002.78,2299.81
  region net NetR3_1: 2913.82,2396.73 2913.82,2353.25 2928.07,2339 2928.07,2318.18 2919.27,2309.37 2876.02,2309.37 2869.1,2316.29 2869.1,2396.02 2880.07,2407 2903.56,2407
  region net VDD_3V3: 2623.62,2290.79 2554.28,2290.79 2533.07,2312 2533.07,2384 2544.81,2395.73 2643.7,2395.73 2643.7,2359.13 2634.07,2349.5 2634.07,2301 2633.82,2301
  region net NetR4_2: 2667.33,2353.25 2651.01,2336.94 2651.01,2317.82 2659.46,2309.37 2708.67,2309.37 2718.07,2318.78 2718.07,2395 2707.07,2406 2674.07,2406 2667.33,2399.25
  region net VM: 3314.06,1536.01 3314.57,1444.5 3319.07,1440 3349.07,1440 3352.07,1443 3352.07,1490 3323.07,1519 3323.07,1624 3322.07,1625 3307.39,1625 3305.6,1623.21 3305.6,1544.47
  region net VDD: 3407.96,1623.21 3407.96,1566.44 3415.41,1559 3481.07,1559 3502.07,1580 3502.07,1652 3498.07,1656 3482.07,1656 3452.07,1626 3410.75,1626
  region net EZFET_USB_Shield: 967.71,3211.75 967.71,2992 1108.51,2992 1108.51,3074 1131.61,3074 1250.54,3074 1250.54,2997.31 1304.22,2997.31 1304.22,2998.8 1401.31,2998.8 1399.73,3211.75
  text ".Layer_Name" at 583.07,-2289.5 h55
Bottom Layer:
  region net EZFET_USB_Shield: 1400.47,2994 956.07,2994 956.07,3218 1400.47,3218
  text ".Layer_Name" at 583.07,-2289.5 h55

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  lines w5: 84.44,1737.02 106.75,1759.69 ; 233,681 198.47,681 198.47,355 311.93,355 311.93,509 383,509 383,697 373,697 ; 453.27,2022.7 463.06,2015.16 ; 504.12,1858.14 524,1874 ; 1115,2875.4 1481,2875.4 1481,2874.24 ; 1122.84,2652.53 1133.19,2668.14 ; 2334.36,396.17 2337,393.12 ; 2421,472.11 2436.64,448.19 ; 2594.41,2857.18 2616.36,2829.11 ; 2825.83,2752.03 2838.12,2735.53 ; 2827.48,453.57 2844.92,473.6 ; 2890.9,397.47 2896.06,392 ; 3189.78,2856.17 3214.14,2832.24 ; 3190,2701 3218,2712 ; 3447.18,562.79 3466.45,546.2 ; 3505.98,2682.59 3509,2634 ; 3525.83,715.85 3532.46,712.53 ; 3532.35,569.41 3574,549 ; 3549.9,2642.86 3579.7,2689.91 ; 3621.25,1274.74 3642.29,1300.63 ; 3711.51,556.99 3726.04,543.61 ; 3779.29,566.96 3827,545 ; 3781,728 3793,717 ; 3950,2658 3987.49,2703.93 ; 4011,2653 4122,2708 ; 4118,2088 4130.42,2099.07 ; 4126.23,591.53 4162.22,592.41 ; 4136.03,975.27 4150.95,985.44 ; 4164.61,767.69 4173.72,784.7 ; 4169,96 4228,96 ; 4192.69,2092.62 4206.58,2102.79 ; 4207.92,1111.28 4218.12,1114.28 ; 4212.35,814.93 4218.37,810.12 ; 4221,2932 4391,2932 4391,2978 4563,2978 4563,2746 4342,2746 4342,2932 4266,2932 ; 4245.76,438.95 4288.28,462.25 ; 4284,2096 4291.14,2105.43 ; 4472.38,2046.28 4519.98,2033.83 ; 4228,96 4228,125 4267,125 4267,252 4422,252 4422,153 4465,153 4465,28 4228,28 4228,96 ; 669,2674 669,2680 669,2944 936,2944 936,2972 1115,2972 1115,2850 899,2850 899,2686 820,2686 820,2674 669,2674 ; 751,2536.74 816,2536.74 816,2513.82 998.45,2513.82 998.45,2396.54 1197.57,2396.54 1197.57,2518 1055,2518 1055,2664.4 814.63,2664.4 814.63,2650 751,2650 751,2536.74 ; 1108.5,1093 1108.5,1356 1224,1356 1224,1594 1258,1594 1462,1594 1462,1353 1283,1353 1283,1093 1108.5,1093 ; 1481,2668.95 1481,2953.95 1837,2953.95 1837,2668.95 1481,2668.95
  lines w6: 788.98,3060.95 788.98,3152.37 ; 789.64,3060.95 885.14,3060.77 ; 916.71,1629.79 916.71,1721.21 ; 917.37,1629.79 1012.87,1629.61 ; 193.05,2966.12 885.14,2966.12 885.14,3155.43 193.05,3155.43 193.05,2966.12 ; 320.78,1634.95 1012.87,1634.95 1012.87,1824.26 320.78,1824.26 320.78,1634.95
  lines w10: 904.53,3075.4 904.53,3148.92 ; 1028.33,1643.11 1028.33,1716.64 ; 2227.91,1364 2392.25,1364 ; 2238,2044 2366.07,2044 ; 2241.99,2174.24 2367.43,2175.36 ; 2242,1914 2361.19,1914 ; 2247.02,1496.28 2374.82,1495.25 ; 2253,1644 2373.14,1644 ; 1539,437.44 1539,1046 2063,1046 2063,1024 2215,1024 2215,437.44 1539,437.44 ; 3108.48,1519 3603.63,1519 3603.63,2019.01 3108.48,2019.01 3108.48,1519
  text "For EZFET-LITE Flashing Only" at 152.48,3186.58 h30
  text "VM" at 4469.53,3029.89 h35 r90
  text "GND" at 2118,3025 h35
  text "GND" at 4393.84,2759.99 h35 r90
  text "OUT2_S" at 4448.48,2759.99 h35 r90
  text "OUT2_D" at 4504.48,2759.99 h35 r90
  text "VM" at 4556.53,2759.99 h35 r90
  text "GND" at 2809,2730 h35 r90
  text "VM" at 3870.89,2665.47 h35
  text "OUT4_HS" at 3269,2645 h35 r90
  text "OUT6_HS" at 2673.92,2621.66 h35 r90
  text "OUT2_D" at 3804,2609 h35
  text "GND" at 3751.63,2605.02 h35 r90
  text "OUT2_S" at 3376.46,2585.73 h35
  text "GND" at 2499.4,2573.93 h35
  text "GND" at 2273.41,2568.67 h35
  text "1" at 366.07,2444 h35
  text "GND" at 2171,2260 h35
  text "GND" at 1759,2251 h35
  text "VS" at 3112,2212 h35
  text "nSCS" at 2261.07,2189 h35
  text "GND" at 1281,2184 h35
  text "RST" at 1278.59,2105.46 h35
  text "SCLK" at 2256.07,2064 h35
  text "DRV81242-Q1" at 3128.83,1962.54 h35
  text "SDI" at 2261.07,1934 h35
  text "GND" at 97,1915 h35 r90
  text "GND" at 2496.41,1911.67 h35
  text "SDO" at 2261.07,1799 h35
  text "PUSH" at 1123.99,1730.9 h35
  text "RST" at 1379.84,1728.37 h35
  text "nSLEEP" at 2251.07,1664 h35
  text "3V3" at 266,1576 h35 r90
  text "GND" at 3907.99,1575.16 h35
  text "EZFET_VCC" at 68,1534 h35 r90
  text "IN1" at 2261.07,1519 h35
  text "GND" at 4336,1402 h35
  text "3V3" at 384,1400 h35
  text "IN0" at 2261.07,1379 h35
  text "GND" at 2495.41,1362.67 h35
  text "VDD_3V3" at 3668.33,1313.41 h35 r90
  text "3V3" at 2251.07,1209 h35
  text "MD091A" at 3030,1177 h60
  text "GND" at 2251.07,1074 h35
  text "GND" at 2460.58,993.5 h35 r90
  text "GND" at 3019.33,984.41 h35 r90
  text "CH6" at 1706,923 h35 r90
  text "CH4" at 1844,920 h35 r90
  text "CH2" at 1977,918 h35 r90
  text "OUT0_LS" at 4200,918 h35 r90
  text "CH0" at 2122,916 h35 r90
  text "VM" at 3976,871 h35 r90
  text "DRV81242-Q1" at 2585.64,866.69 h35
  text "VM_HS" at 3476,796 h35
  text "VM" at 3664.37,796.45 h35
  text "VM" at 4146.86,796.11 h35
  text "GND" at 3454.33,585.41 h35 r90
  text "OUT3_S" at 3511.87,565.33 h35 r90
  text "VM" at 3717.33,564.25 h35 r90
  text "OUT3_D" at 3765.26,562.36 h35 r90
  text "CHANNEL STATUS" at 1617.73,499.83 h35 r90
  text "GND" at 3233.33,481.41 h35 r90
  text "CH1" at 2120,469 h35 r90
  text "GND" at 2670.33,467.41 h35 r90
  text "CH5" at 1839,465 h35 r90
  text "CH7" at 1706,461 h35 r90
  text "CH3" at 1987,460 h35 r90
  text "OUT7_HS" at 2256.08,404.18 h35
  text "OUT5_HS" at 2786.33,404.18 h35
  text "OUT1_LS" at 4208.67,374.28 h35 r90
  text "MCU_3V3" at 360.37,227.37 h35 r90
  text "GND" at 3270.82,176.22 h35 r90
  text "DRV_STATUS" at 1147.1,175.29 h35 r90
  text "MCU_STATUS" at 680.24,174 h35 r90
  text "GUI_STATUS" at 975.24,164 h35 r90
  text "FAULT_STATUS" at 1312.17,159 h35 r90
  text "VM" at 4288.26,46.36 h35 r90
  text "OUT3_D" at 4339.48,41.99 h35 r90
  text "OUT3_S" at 4395.48,41.99 h35 r90
  text "GND" at 4448.49,42.28 h35 r90
  text ".Layer_Name" at 583.07,-2289.5 h55
Bottom Overlay:
  text ".Layer_Name" at 583.07,-2289.5 h55
Top Paste:
  text ".Layer_Name" at 583.07,-2289.5 h55
Bottom Paste:
  text ".Layer_Name" at 583.07,-2289.5 h55
Top Solder:
  text ".Layer_Name" at 583.07,-2289.5 h55
  text ".Layer_Name" at 583.07,-2289.5 h55
Bottom Solder:
  text ".Layer_Name" at 583.07,-2289.5 h55
Drill Guide:
  text ".Layer_Name" at 583.07,-2289.5 h55
M1 Board Outline:
  the board outline again, w10
  text ".Layer_Name" at 583.07,-2289.5 h55
M2 Board Dimensions:
  rectangle: 6.07,-1706 131.07,-1581
  rectangle: 131.07,-1831 506.07,-1706
  lines w7: 6.07,-1706 1006.07,-1706 ; 131.07,-1831 131.07,-1581 ; 256.07,-1831 256.07,-1581 ; 506.07,-1831 506.07,-1581 ; 756.07,-1831 756.07,-1581 ; 6.07,-1831 1006.07,-1831 1006.07,-1581 6.07,-1581 6.07,-1831
  text ".Layer_Name" at 583.07,-2289.5 h55
M3 3D STEP Top:
  text ".Layer_Name" at 583.07,-2289.5 h55
M4 3D STEP Bottom:
  text ".Layer_Name" at 583.07,-2289.5 h55
M5 Assembly Top:
  lines w10: -285.93,-2361.17 6314.07,-2361.17 ; -285.93,-2157.84 6316.07,-2157.84 ; -285.93,-1954.5 -285.93,-2564.5 3719.07,-2564.5 6316.07,-2564.5 6316.07,-1954.5 -285.43,-1954.5 -285.43,-2564.5 1290.07,-2564.5 ; 2179.07,-2564.5 2179.07,-1954.5 ; 3446.07,-2157.84 3446.07,-1954.5 ; 4286.07,-2157.84 4286.07,-1954.5 ; 4908.07,-2571 4908.07,-2368.17
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 1159.57,-1749.5 h55
  text "ASSEMBLY VARIANT:" at 1159.07,-1865 h55
  text ".VariantName" at 2195.07,-1865 h55
  text "PCB VIEWED FROM TOP SIDE" at -222.43,-2086.67 h55
  text "BOARD #:" at 2254.07,-2086.67 h55
  text ".PRJ_Number" at 2799.57,-2086.67 h55
  text "REV:" at 3644.07,-2086.67 h55
  text ".PCB_Rev" at 3935.57,-2086.67 h55
  text "SVN REV:" at 4482.07,-2086.67 h55
  text ".VersionControl_RevNumber" at 4988.07,-2086.67 h55
  text "TID #:" at 2254.07,-2290 h55
  text ".TID" at 2799.57,-2290 h55
  text "PLOT NAME =" at -222.43,-2495.34 h55
  text ".plot_File_Name" at 583.07,-2495.34 h55
  text "GENERATED    :" at 2256.07,-2495.34 h55
  text ".Print_Date" at 3125.57,-2495.34 h55
  text ".Print_Time" at 3854.57,-2495.34 h55
  text "TEXAS INSTRUMENTS" at 5119.07,-2495.34 h55
M6 Assembly Bottom:
  lines w10: -286.43,-2158.34 6315.57,-2158.34 ; -284.43,-2361.67 6315.57,-2361.67 ; 1121.57,-2571.5 1121.57,-2368.67 ; 1743.57,-2158.34 1743.57,-1955 ; 2583.57,-2158.34 2583.57,-1955 ; 3850.57,-2565 3850.57,-1955 ; 4739.57,-2565 6315.07,-2565 6315.07,-1955 -286.43,-1955 -286.43,-2565 2310.57,-2565 6315.57,-2565 6315.57,-1955
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 6108.07,-1749 h55
  text ".VariantName" at 5064.07,-1865 h55
  text "ASSEMBLY VARIANT:" at 6103.07,-1865 h55
  text ".VersionControl_RevNumber" at 1041.57,-2087.17 h55
  text "SVN REV:" at 1547.57,-2087.17 h55
  text ".PCB_Rev" at 2094.07,-2087.17 h55
  text "REV:" at 2385.57,-2087.17 h55
  text ".PRJ_Number" at 3230.07,-2087.17 h55
  text "BOARD #:" at 3775.57,-2087.17 h55
  text "PCB VIEWED FROM BOTTOM SIDE" at 6252.07,-2087.17 h55
  text ".TID" at 3230.07,-2290.5 h55
  text "TID #:" at 3775.57,-2290.5 h55
  text "TEXAS INSTRUMENTS" at 910.57,-2495.84 h55
  text ".Print_Time" at 2175.07,-2495.84 h55
  text ".Print_Date" at 2904.07,-2495.84 h55
  text "GENERATED    :" at 3773.57,-2495.84 h55
  text ".plot_File_Name" at 5446.57,-2495.84 h55
  text "PLOT NAME =" at 6252.07,-2495.84 h55
M9 Title Sheet:
  drawing of 57 lines, arcs and shapes, not listed
  text "1" at 745.91,6605.5 h25
  text "2" at 3241.57,6605.5 h25
  text "3" at 5730.92,6605.5 h25
  text "4" at 8237.59,6605.5 h25
  text "5" at 10736.57,6605.5 h25
  text "6" at 13241.57,6605.5 h25
  text "A" at -410.43,5462.5 h25
  text "A" at 14389.57,5462.5 h25
  text "B" at -410.43,3082.5 h25
  text "B" at 14389.57,3082.5 h55
  text "C" at -410.43,707.5 h25
  text "C" at 14389.57,707.5 h55
  text "PROJECT TITLE:" at 11349.57,-1153.5 h55
  text "DRV81242EVM" at 11399.57,-1286.83 h55
  text "DESIGNED FOR:" at 11349.57,-1454.5 h55
  text ".PRJ_Customer" at 11399.57,-1594.5 h55
  text "D" at -410.43,-1662.5 h55
  text "D" at 14389.57,-1662.5 h55
  text "FILE NAME:" at 11349.57,-1754.5 h55
  text ".PCB_File_Name_No_Path" at 11399.57,-1874.5 h55
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 6380.07,-2036.34 h40
  text "ENGINEER:" at 11349.57,-2044.5 h55
  text "LAYOUT BY:" at 12854.57,-2044.5 h55
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 6335.09,-2149.01 h40
  text ".PRJ_Engineer" at 11399.57,-2199.5 h55
  text ".PCB_Layout" at 12905.07,-2199.5 h55
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 6335.09,-2261.67 h40
  text ".Layer_Name" at 583.07,-2289.5 h55
  text "ALTIUM DESIGNER VERSION:" at 12854.57,-2354.5 h55
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 6335.09,-2374.34 h40
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 6380.07,-2487 h40
  text ".print_Scale" at 11399.57,-2487.83 h55
  text ".Application_BuildNumber" at 12905.07,-2487.83 h55
  text "1" at 745.91,-2694.5 h55
  text "2" at 3241.57,-2694.5 h55
  text "3" at 5730.92,-2694.5 h55
  text "4" at 8237.59,-2694.5 h55
  text "5" at 10736.57,-2694.5 h25
  text "6" at 13241.57,-2694.5 h55
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 12388.09,4925.17 h55
  text "MIN. TRACK WIDTH:" at 11743.53,4793.04 h55
  text "8" at 12839.78,4793.05 h55
  text "MIL" at 12994.53,4793.04 h55
  text "MIN. CLEARANCE:" at 11743.53,4668.92 h55
  text "0.2" at 12779.78,4668.92 h55
  text "mm" at 12994.53,4668.92 h55
  text "MIN. VIA PAD SIZE:" at 11743.53,4544.79 h55
  text "24" at 12809.79,4544.8 h55
  text "MIL" at 12994.53,4544.79 h55
  text "0.05mm (2MIL)" at 12438.53,4414.89 h55
  text "MINIMUM ANNULAR RING" at 11414.3,4406.67 h55
  text "EXTERNAL" at 13146.53,4406.67 h55
  text "PER" at 11614.3,4296.54 h55
  text "IPC-D-275 CLASS 2 LEVEL C" at 11834.3,4296.54 h55
  text "MIL, HOLES" at 13322.53,4196.06 h55
  text "+/-" at 12930.07,4187.48 h55
  text "+/-" at 13784.07,4187.48 h55
  text "REGISTRATION TOLERANCES:" at 11414.3,4186.41 h55
  text "METAL" at 12614.07,4186.41 h55
  text "5" at 13190.28,4186.42 h55
  text "3" at 14023.28,4186.42 h55
  text "MIL" at 14139.53,4186.41 h55
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 11414.3,4088.1 h55
  text "+/-" at 13784.07,4085.23 h55
  text "3" at 14023.28,4084.17 h55
  text "MIL" at 14139.53,4084.16 h55
  text "MATERIAL:" at 11339.53,3946.52 h55
  text "FR-4 High Tg" at 12325.98,3817.99 h55
  text "X" at 12181.54,3810 h55
  text "FR-408" at 11760.54,3805.48 h55
  text "OTHER" at 13248.53,3805.48 h55
  text "62 MIL (1.6mm) +/-10%" at 12080.64,3662.46 h55
  text "X" at 11960.54,3660 h55
  text "THICKNESS:" at 11414.3,3654.23 h55
  text "OTHER" at 13365.53,3654.23 h55
  text "TOLERANCE:" at 11414.3,3515.92 h55
  text "X" at 12262.54,3515.92 h55
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12440.55,3515.92 h55
  text "OTHER +/-" at 12440.53,3371.73 h55
  text "BOW & TWIST:" at 11414.3,3226.54 h55
  text "X" at 12262.54,3226.54 h55
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12440.55,3226.54 h55
  text "OTHER +/-" at 12440.53,3079.84 h55
  text "DRILLING:" at 11339.53,2949.23 h55
  text "NC_DRILL FILES" at 13100.53,2844.04 h55
  text "REFERENCE:" at 11414.3,2840.1 h55
  text "X" at 12071.54,2840 h55
  text "AS SHOWN" at 12249.53,2840.1 h55
  text "X" at 12972.54,2840.1 h55
  text "OTHER" at 13398.53,2697.85 h55
  text "PTH COPPER THICKNESS:" at 11413.98,2694.32 h55
  text "X" at 12553.22,2694.32 h55
  text "20-30 um" at 12681.21,2694.32 h55
  text "BOARD FINISH:" at 11339.53,2546.72 h55
  text "SILKSCREEN:" at 11494.76,2436.6 h55
  text "X" at 12452.54,2436.6 h55
  text "TOP" at 12569.53,2436.6 h55
  text "X" at 12962.54,2436.6 h55
  text "BOTTOM" at 13080.53,2436.6 h55
  text "SILKSCREEN COLOR:" at 11494.76,2281.41 h55
  text "X" at 12451.54,2281.41 h55
  text "WHITE" at 12569.53,2281.41 h55
  text "OTHER" at 13080.53,2281.41 h55
  text "X" at 12582.54,2137.96 h55
  text "GREEN" at 12700.53,2137.96 h55
  text "OTHER" at 13318.53,2137.96 h55
  text "SOLDER RESIST COLOR:" at 11494.76,2131.09 h55
  text "X" at 12582.54,1983.71 h55
  text "MATTE" at 12700.53,1983.71 h55
  text "SEMI-GLOSS" at 13318.07,1983.07 h55
  text "IMMERSION GOLD (ENIG)" at 12400.53,1810.94 h55
  text "ENEPIG" at 13738.07,1803.71 h55
  text "SURFACE FINISH:" at 11339.53,1802.71 h55
  text "X" at 12222.54,1802.71 h55
  text "IMM. TIN/SILVER OR EQUIV" at 11669.07,1665.4 h55
  text "OTHER" at 13100.53,1661.46 h55
  text "ARRAY/PANEL:" at 11339.53,1506.08 h55
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 12400.54,1497.86 h55
  text "N.C. ROUTE" at 12400.53,1361.89 h55
  text "X" at 13088.54,1361.89 h55
  text "V. SCORE" at 13266.53,1361.89 h55
  text "CERTIFICATION:" at 11339.53,1232.77 h55
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 12064.53,1232.77 h55
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 12064.53,1138.71 h55
  text "X" at 11702.04,1010.08 h55
  text "ANSI IPC-A-600F CLASS ->" at 11830.04,1010.08 h55
  text "X" at 13478.04,1010.08 h55
  text "2" at 13588.04,1010.08 h55
  text "1" at 13273.04,1008.58 h55
  text "3" at 13942.04,1008.58 h55
  text "X" at 12514.04,862.39 h55
  text "RoHS" at 12642.04,862.39 h55
  text "OTHER" at 13286.44,862.39 h55
  text "PER ORDER" at 13683.5,862.39 h55
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 11367.07,708.56 h55
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 11367.07,592.5 h55
  text "ADDITIONAL REQUIREMENTS:" at 11339.53,423.08 h55
  text "FAB NOTES:" at 5767.98,337.5 h55
  text "MICROSECTION:" at 11414.3,315.95 h55
  text "YES" at 12320.04,315.95 h55
  text "1. NO VENDOR LOGO OR NAME ON THE BOARD." at 5766.98,210.81 h55
  text "REQUIRED" at 13181.53,171.62 h55
  text "BARE BOARD ELEC. TEST:" at 11414.3,168.76 h55
  text "NONE" at 12720.04,168.76 h55
  text "X" at 13063.54,168.76 h55
  text "PER ORDER" at 13773.53,168.76 h55
  text "2. ALL HOLES SHOULD BE FHS." at 5766.98,88.18 h55
  text "3. CLIP SILK ON NO MASK AREA." at 5770.98,-32.02 h55
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 11582.45,-36.19 h55
  text "4. 7.87MIL DRILLS NEED TO BE NON-CONDUCTIVE SOLDER MASK PLUGGING FROM BOTTOM SIDE" at 5769.05,-119.91 h55
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 11590.45,-140.16 h55
  text "5.REMOVE NON-FUNCTIONAL PADS IN INNER LAYER ." at 5772.05,-215.91 h55
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 11589.47,-303.55 h55
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 11581.47,-539.26 h55
  text ".Layer_Name" at 583.07,-2289.5 h55
M11 Gerber Information:
  circle w10: c4752.8,3686.2 r42.65
  circle w10: c4752.9,3686.1 r87.29
  circle w10: c-25.2,-163.8 r42.65
  circle w10: c-25.1,-163.9 r87.29
  circle w10: c4678.8,-149.8 r42.65
  circle w10: c4678.9,-149.9 r87.29
  lines w10: -285.93,-2361.17 6314.07,-2361.17 ; -285.93,-2157.84 6316.07,-2157.84 ; -285.93,-1954.5 -285.93,-2564.5 3719.07,-2564.5 6316.07,-2564.5 6316.07,-1954.5 -285.43,-1954.5 -285.43,-2564.5 1290.07,-2564.5 ; -157.6,-163 -26,-163 ; -26,-294.6 -26,-163 ; -26,-31.4 -26,-163 ; 105.6,-163 -26,-163 ; 2179.07,-2564.5 2179.07,-1954.5 ; 3446.07,-2157.84 3446.07,-1954.5 ; 4286.07,-2157.84 4286.07,-1954.5 ; 4546.4,-149 4678,-149 ; 4620.4,3687 4752,3687 ; 4678,-280.6 4678,-149 ; 4678,-17.4 4678,-149 ; 4752,3555.4 4752,3687 ; 4752,3818.6 4752,3687 ; 4809.6,-149 4678,-149 ; 4883.6,3687 4752,3687 ; 4908.07,-2571 4908.07,-2368.17
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -222.43,-2086.67 h55
  text "BOARD #:" at 2254.07,-2086.67 h55
  text "REV:" at 3644.07,-2086.67 h55
  text ".PCB_Rev" at 3935.57,-2086.67 h55
  text "SVN REV:" at 4482.07,-2086.67 h55
  text ".VersionControl_RevNumber" at 4988.07,-2086.67 h55
  text "DRV81242EVM" at 2725,-2096 h55
  text "LAYER NAME =" at -222.43,-2289.5 h55
  text "TID #:" at 2254.07,-2290 h55
  text ".TID" at 2799.57,-2290 h55
  text ".plot_File_Name" at 416,-2490 h40
  text "PLOT NAME =" at -222.43,-2495.34 h55
  text "GENERATED    :" at 2256.07,-2495.34 h55
  text ".Print_Date" at 3125.57,-2495.34 h55
  text ".Print_Time" at 3854.57,-2495.34 h55
  text "TEXAS INSTRUMENTS" at 5119.07,-2495.34 h55
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Stackup:" at 6604.76,1999.73 h70
  text "Layer" at 6668.78,1873.1 h46.96
  text "Name" at 6993.96,1873.1 h46.96
  text "Material" at 7733.84,1873.1 h46.96
  text "Thickness" at 8411.12,1873.1 h46.96
  text "Constant" at 8924.09,1873.1 h46.96
  text "Board Layer Stack" at 9374.47,1873.1 h46.96
  text "Top Overlay" at 6993.96,1779.18 h46.96
  text "Top Solder" at 6993.96,1685.25 h46.96
  text "Solder Resist" at 7733.84,1685.25 h46.96
  text "0.40mil" at 8411.12,1685.25 h46.96
  text "3.5" at 8924.09,1685.25 h46.96
  text "1" at 6668.78,1591.33 h46.96
  text "Top Layer" at 6993.96,1591.33 h46.96
  text "2.80mil" at 8411.12,1591.33 h46.96
  text "Dielectric 1" at 6993.96,1497.4 h46.96
  text "FR4 370" at 7733.84,1497.4 h46.96
  text "11.40mil" at 8411.12,1497.4 h46.96
  text "4.2" at 8924.09,1497.4 h46.96
  text "2" at 6668.78,1403.48 h46.96
  text "Signal Layer 1" at 6993.96,1403.48 h46.96
  text "1.40mil" at 8411.12,1403.48 h46.96
  text "Dielectric 2" at 6993.96,1309.56 h46.96
  text "FR4 370" at 7733.84,1309.56 h46.96
  text "30.00mil" at 8411.12,1309.56 h46.96
  text "4.2" at 8924.09,1309.56 h46.96
  text "3" at 6668.78,1215.63 h46.96
  text "Signal Layer 2" at 6993.96,1215.63 h46.96
  text "1.40mil" at 8411.12,1215.63 h46.96
  text "Dielectric 3" at 6993.96,1121.71 h46.96
  text "FR4 370" at 7733.84,1121.71 h46.96
  text "11.40mil" at 8411.12,1121.71 h46.96
  text "4.2" at 8924.09,1121.71 h46.96
  text "4" at 6668.78,1027.79 h46.96
  text "Bottom Layer" at 6993.96,1027.79 h46.96
  text "2.80mil" at 8411.12,1027.79 h46.96
  text "Bottom Solder" at 6993.96,933.86 h46.96
  text "Solder Resist" at 7733.84,933.86 h46.96
  text "0.40mil" at 8411.12,933.86 h46.96
  text "3.5" at 8924.09,933.86 h46.96
  text "Bottom Overlay" at 6993.96,839.94 h46.96
  text ".Layer_Name" at 583.07,-2289.5 h55
M13 Component Bodies Top:
  text ".Layer_Name" at 583.07,-2289.5 h55
M14 Component Bodies Bottom:
  text ".Layer_Name" at 583.07,-2289.5 h55
M15 Courtyards Top:
  text ".Layer_Name" at 583.07,-2289.5 h55
M16 Courtyards Bottom:
  text ".Layer_Name" at 583.07,-2289.5 h55
Drill Drawing:
  circle w8: c6548.03,3509.53 r11.39
  circle w8: c6548.03,3509.53 r18.98
  circle w8: c6548.03,2826.24 r18.98
  lines w8: 6529.05,2465.62 6567.01,2465.62 6567.01,2503.58 6529.05,2503.58 6529.05,2465.62 ; 6529.05,2551.03 6567.01,2551.03 6567.01,2588.99 6529.05,2588.99 6529.05,2551.03 ; 6529.05,2645.93 6538.54,2645.93 6548.03,2636.44 6557.52,2645.93 6567.01,2645.93 6557.52,2655.42 6567.01,2664.91 6557.52,2664.91 6548.03,2674.4 6538.54,2664.91 6529.05,2664.91 6538.54,2655.42 6529.05,2645.93 ; 6529.05,2721.85 6548.03,2731.34 6567.01,2721.85 6557.52,2740.83 6567.01,2759.81 6548.03,2750.32 6529.05,2759.81 6538.54,2740.83 6529.05,2721.85 ; 6529.05,2930.63 6567.01,2930.63 6548.03,2892.67 6529.05,2930.63 ; 6529.05,3016.05 6567.01,3016.05 6548.03,2978.09 6529.05,3016.05 ; 6529.05,3082.48 6548.03,3063.5 6567.01,3082.48 6548.03,3101.46 6529.05,3082.48 ; 6529.05,3148.91 6548.03,3158.4 6567.01,3148.91 6557.52,3167.89 6567.01,3186.87 6548.03,3177.38 6529.05,3186.87 6538.54,3167.89 6529.05,3148.91 ; 6529.05,3234.32 6529.05,3243.81 6538.54,3253.3 6529.05,3262.79 6529.05,3272.28 6538.54,3272.28 6548.03,3262.79 6557.52,3272.28 6567.01,3272.28 6567.01,3262.79 6557.52,3253.3 6567.01,3243.81 6567.01,3234.32 6557.52,3234.32 6548.03,3243.81 6538.54,3234.32 6529.05,3234.32 ; 6529.05,3329.22 6538.54,3329.22 6548.03,3319.73 6557.52,3329.22 6567.01,3329.22 6557.52,3338.71 6567.01,3348.2 6557.52,3348.2 6548.03,3357.69 6538.54,3348.2 6529.05,3348.2 6538.54,3338.71 6529.05,3329.22 ; 6529.05,3414.63 6538.54,3414.63 6538.54,3405.14 6557.52,3405.14 6557.52,3414.63 6567.01,3414.63 6567.01,3433.61 6557.52,3433.61 6557.52,3443.1 6538.54,3443.1 6538.54,3433.61 6529.05,3433.61 6529.05,3414.63 ; 6536.64,2558.62 6559.42,2558.62 6559.42,2581.4 6536.64,2581.4 6536.64,2558.62 ; 6536.64,2729.44 6548.03,2735.14 6559.42,2729.44 6553.73,2740.83 6559.42,2752.22 6548.03,2746.53 6536.64,2752.22 6542.34,2740.83 6536.64,2729.44 ; 6536.64,3008.45 6559.42,3008.45 6548.03,2985.68 6536.64,3008.45 ; 6536.64,3333.02 6542.34,3333.02 6548.03,3327.32 6553.73,3333.02 6559.42,3333.02 6553.73,3338.71 6559.42,3344.4 6553.73,3344.4 6548.03,3350.1 6542.34,3344.4 6536.64,3344.4 6542.34,3338.71 6536.64,3333.02
  lines w10: 6494.29,2440 10187.5,2440 ; 6494.29,3550.34 10187.5,3550.34 ; 6815.34,2354.58 6815.34,3635.75 ; 7185.9,2354.58 7185.9,3635.75 ; 7959.47,2354.58 7959.47,3635.75 ; 8254.9,2354.58 8254.9,3635.75 ; 8680.11,2354.58 8680.11,3635.75 ; 9538.58,2354.58 9538.58,3635.75 ; 6494.29,2354.58 10187.5,2354.58 10187.5,3635.75 6494.29,3635.75 6494.29,2354.58
  text "Drill Drawing :" at 6499,3670.99 h60
  text "Symbol" at 6545.53,3575.96 h41
  text "Quantity" at 6840.96,3575.96 h41
  text "Finished Hole Size" at 7211.52,3575.96 h41
  text "Plated" at 7985.1,3575.96 h41
  text "Hole Type" at 8280.53,3575.96 h41
  text "Drill Layer Pair" at 8705.74,3575.96 h41
  text "Hole Tolerance" at 9564.2,3575.96 h41
  text "37" at 6840.96,3490.55 h34.16
  text "7.87mil (0.200mm)" at 7211.52,3490.55 h34.16
  text "PTH" at 7985.1,3490.55 h34.16
  text "Round" at 8280.53,3490.55 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,3490.55 h34.16
  text "+3mil/-3mil" at 9564.2,3490.55 h34.16
  text "53" at 6840.96,3405.14 h34.16
  text "8.00mil (0.203mm)" at 7211.52,3405.14 h34.16
  text "PTH" at 7985.1,3405.14 h34.16
  text "Round" at 8280.53,3405.14 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,3405.14 h34.16
  text "+3mil/-3mil" at 9564.2,3405.14 h34.16
  text "11" at 6840.96,3319.73 h34.16
  text "10.00mil (0.254mm)" at 7211.52,3319.73 h34.16
  text "PTH" at 7985.1,3319.73 h34.16
  text "Round" at 8280.53,3319.73 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,3319.73 h34.16
  text "+3mil/-3mil" at 9564.2,3319.73 h34.16
  text "195" at 6840.96,3234.32 h34.16
  text "16.00mil (0.406mm)" at 7211.52,3234.32 h34.16
  text "PTH" at 7985.1,3234.32 h34.16
  text "Round" at 8280.53,3234.32 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,3234.32 h34.16
  text "+3mil/-3mil" at 9564.2,3234.32 h34.16
  text "7" at 6840.96,3148.91 h34.16
  text "17.72mil (0.450mm)" at 7211.52,3148.91 h34.16
  text "PTH" at 7985.1,3148.91 h34.16
  text "Round" at 8280.53,3148.91 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,3148.91 h34.16
  text "+3mil/-3mil" at 9564.2,3148.91 h34.16
  text "44" at 6840.96,3063.5 h34.16
  text "40.00mil (1.016mm)" at 7211.52,3063.5 h34.16
  text "PTH" at 7985.1,3063.5 h34.16
  text "Round" at 8280.53,3063.5 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,3063.5 h34.16
  text "+3mil/-3mil" at 9564.2,3063.5 h34.16
  text "28" at 6840.96,2978.09 h34.16
  text "43.31mil (1.100mm)" at 7211.52,2978.09 h34.16
  text "PTH" at 7985.1,2978.09 h34.16
  text "Round" at 8280.53,2978.09 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,2978.09 h34.16
  text "+3mil/-3mil" at 9564.2,2978.09 h34.16
  text "3" at 6840.96,2892.67 h34.16
  text "45.28mil (1.150mm)" at 7211.52,2892.67 h34.16
  text "PTH" at 7985.1,2892.67 h34.16
  text "Round" at 8280.53,2892.67 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,2892.67 h34.16
  text "+3mil/-3mil" at 9564.2,2892.67 h34.16
  text "26" at 6840.96,2807.26 h34.16
  text "51.18mil (1.300mm)" at 7211.52,2807.26 h34.16
  text "PTH" at 7985.1,2807.26 h34.16
  text "Round" at 8280.53,2807.26 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,2807.26 h34.16
  text "+3mil/-3mil" at 9564.2,2807.26 h34.16
  text "2" at 6840.96,2721.85 h34.16
  text "59.06mil (1.500mm)" at 7211.52,2721.85 h34.16
  text "PTH" at 7985.1,2721.85 h34.16
  text "Round" at 8280.53,2721.85 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,2721.85 h34.16
  text "+3mil/-3mil" at 9564.2,2721.85 h34.16
  text "23" at 6840.96,2636.44 h34.16
  text "63.00mil (1.600mm)" at 7211.52,2636.44 h34.16
  text "PTH" at 7985.1,2636.44 h34.16
  text "Round" at 8280.53,2636.44 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,2636.44 h34.16
  text "+3mil/-3mil" at 9564.2,2636.44 h34.16
  text "2" at 6840.96,2551.03 h34.16
  text "25.59mil (0.650mm)" at 7211.52,2551.03 h34.16
  text "PTH" at 7985.1,2551.03 h34.16
  text "Slot" at 8280.53,2551.03 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,2551.03 h34.16
  text "+3mil/-3mil" at 9564.2,2551.03 h34.16
  text "2" at 6840.96,2465.62 h34.16
  text "51.18mil (1.300mm)" at 7211.52,2465.62 h34.16
  text "PTH" at 7985.1,2465.62 h34.16
  text "Slot" at 8280.53,2465.62 h34.16
  text "Top Layer - Bottom Layer" at 8705.74,2465.62 h34.16
  text "+3mil/-3mil" at 9564.2,2465.62 h34.16
  text "433 Total" at 6840.96,2380.21 h34.16
  text "Slot definitions :" at 6545.53,2293.05 h34.16
  text "Routed Path Length" at 7140.01,2293.05 h34.16
  text "= Calculated from tool start centre position to tool end centre position." at 7774.33,2293.05 h34.16
  text "Hole Length" at 7140.01,2231.51 h34.16
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 7540.95,2231.51 h34.16
  text ".Layer_Name" at 583.07,-2289.5 h55
Mechanical 17:
  text ".Layer_Name" at 583.07,-2289.5 h55
Mechanical 18:
  text ".Layer_Name" at 583.07,-2289.5 h55
Mechanical 19:
  text ".Layer_Name" at 583.07,-2289.5 h55

## Dimensions
5.07,3250 to 0,0 on M2 Board Dimensions
5.07,3250 to 4586.07,3247 on M2 Board Dimensions