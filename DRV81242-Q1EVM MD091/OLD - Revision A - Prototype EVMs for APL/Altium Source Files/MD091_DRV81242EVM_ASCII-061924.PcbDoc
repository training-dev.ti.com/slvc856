# Altium PCB MD091_DRV81242EVM_ASCII-061924.PcbDoc (part 4 of 5)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4586.07 x 3253 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 237 components, 133 nets, 665 pads, 296 vias.

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
0402 [mm] "0402 from SM-752 data"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -1.22,-0.52 1.22,0.52
0402L [mm] "0402 from SM-752 data"
  rect 0.6x0.5 smd: 1(-0.5,0) 2(0.5,0)
0402S [mil] "Based on C0402S footprint from PADS legacy"
  rect 15x24 smd: 1(-20,0) 2(20,0)
0603 [mm] "0603 from SM-752 data"
  rect 1x0.95 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.52,-0.69 1.52,0.69
0603L [mm] "0603 from SM-752 data"
  rect 0.8x0.85 smd: 1(-0.7,0) 2(0.7,0)
  silkscreen extent -0.07,-0.33 0.07,0.33
0805_150 [mm] "0805 / 1.5 mm height"
  rect 1.15x1.45 smd: 1(-0.9,0) 2(0.9,0)
  silkscreen extent -0.1,-0.8 0.1,0.8
0805_A [mm] "Chip LED, 2-Leads, Body 2.0x1.3mm, IPC Medium Density"
  rect 1.1x1.2 smd: 1(-1.05,0) 2(1.05,0)
  silkscreen extent -0.15,-0.5 0.15,0.5
1206 [mm] "1206 from SM-752 data"
  rect 1.3x1.85 smd: 1(-1.45,0) 2(1.45,0)
  silkscreen extent -2.4,-1.21 2.4,1.21
691101710002 [mm] "5,00mm - modular - blue - Horizontal entry with pressure clamp - 12,6mm height - 02p"
  rect 1.95x1.95 hole 1.3: 1(-2.5,-0.5)
  round 1.95 hole 1.3: 2(2.5,-0.5)
  silkscreen extent -5.6,-4.5 5.6,4.5
CE_Mark_5mm [mil] "Minimum text height for CE Mark"
D0008A_N [mm] "SOIC, 8-Leads, Body 4.9x3.9mm, Pitch 1.27mm, IPC Medium Density"
  oval 1.45x0.6 smd: 1(-2.725,1.905) 2(-2.725,0.635) 3(-2.725,-0.635) 4(-2.725,-1.905) 5(2.725,-1.905) 6(2.725,-0.635) 7(2.725,0.635) 8(2.725,1.905)
  silkscreen extent -3.3,-2.5 0.9,2.5
DRB0008A [mm] "VSON-8"
  rrect32% 0.6x0.31 smd: 1(-1.4,0.975) 2(-1.4,0.325) 3(-1.4,-0.325) 4(-1.4,-0.975) 5(1.4,-0.975) 6(1.4,-0.325) 7(1.4,0.325) 8(1.4,0.975)
  rrect7% 1.5x1.75 smd paste-0.75: 9(0,0)
  silkscreen extent -1.73,-1.73 1.73,1.73
DRY0006A [mm] "USON-6"
  rrect67% 0.45x0.3 smd paste-0.05 mask+0: 1(-0.275,0.5)
  rrect67% 0.4x0.3 smd paste-0.05 mask+0: 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
FCC_disclaimer [mil]
Fiducial10-20 [mm]
  round 1 smd mask+0: 1(0,0)
  Top Layer keep-out circle w1.178: c0,0 r0.5
FP-0603-L_1_6_0_15-W_0_8-IPC_C [mil]
  rect 33.77x33.94 smd paste+0 mask+0: 1(-23.71,0) 2(23.71,0)
  silkscreen extent -41,-34 41,34
FP-150080SS75000-MFG [mm]
  rect 1.1x1.2 smd paste+0 mask+0: 1(-1.05,0) 2(1.05,0)
  silkscreen extent -2.27,-0.67 0.13,0.67
FP-1888700_HDR4-MFG [mm]
  rrect5% 2x2 hole 1.3 paste-1000 mask+0: 1(-7.62,0)
  round 2 hole 1.3 paste-1000 mask+0: 2(-2.54,0) 3(2.54,0) 4(7.62,0)
FP-430481025816_SMT_SW_6MM2_6MM2-MFG [mm]
  rrect7% 2x1.4 smd paste+0 mask+0: 1(-3.5,2) 2(3.5,2) 3(-3.5,-2) 4(3.5,-2)
  silkscreen extent -5.18,-3.2 3.2,3.2
FP-560050310009_0402-MFG [mm]
  rrect25% 0.4x0.5 smd paste+0 mask+0: 1(-0.45,0) 2(0.45,0)
  silkscreen extent -0.5,-0.63 0.5,0.63
FP-629105150921_CONN_PTH_USB_8MM0_5MM6-MFG [mm]
  rrect25% 0.4x1.35 smd paste+0 mask+0: 1(-1.3,2.335) 2(-0.65,2.335) 3(0,2.335) 4(0.65,2.335) 5(1.3,2.335)
  rrect100% 1.15x1.05 hole 0.65 slot 0.75 at 0 deg paste-1000 mask+0: 6(-2.225,2.65) 7(2.225,2.65)
  rrect100% 1.35x1.9 hole 1.3 slot 0.75 at 0 deg paste-1000 mask+0: 8(-4.175,-0.47) 11(4.173,-0.47)
  round 1.71 smd paste+0 mask+0: 8(-3.699,-0.47) 11(3.699,-0.47)
  rrect6% 1.8x1.9 smd paste+0 mask+0: 9(-1.15,-0.47) 10(1.15,-0.47)
  silkscreen extent -3.8,0.86 3.8,3.71
FP-691250610002_CONN_TERM_BLOCK2-MFG [mm]
  rrect4% 2.3x2.3 hole 1.5 paste-1000 mask+0: 1(-2.875,1.65)
  round 2.3 hole 1.5 paste-1000 mask+0: 2(3.475,1.65)
  silkscreen extent -7.52,-6.3 6.85,6.3
FP-875105240001_SMT_CAP_4MM3_4MM3-MFG [mm]
  rrect6% 2.6x1.6 smd paste+0 mask+0: 1(-1.8,0) 2(1.8,0)
  silkscreen extent -3.68,-2.25 2.25,2.25
FP-885012005058_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.53,-0.63 0.53,0.63
FP-885012006085_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-885012106012_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-885012205018_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.5,-0.63 0.5,0.63
FP-885012206050_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-885012206095-MFG [mm]
  rect 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-C0603C-CF-MFG [mm]
  rect 0.75x0.9 smd paste+0 mask+0: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -0.87,-0.85 0.88,0.85
FP-CC0603-DA-MFG [mm]
  rect 0.8x0.9 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.85 0.85,0.85
FP-SG73S1JTTD101J_0603-MFG [mm]
  rrect20% 0.5x0.6 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.13,-0.45 0.13,0.45
FP-ZRB18AR61E106ME01L_0603-MFG [mm]
  rrect13% 0.75x0.9 smd paste+0 mask+0: 1(-0.775,0) 2(0.775,0)
  silkscreen extent 0,-0.5 0,0.5
Harwin_D3082-05 [mm] "Shorting Plug, 10.16mm spacing, TH"
  round 1.8 hole 1.3: 1(-5.08,0) 2(5.08,0)
  silkscreen extent -3.9,-0.53 3.9,0.53
IEC_Caution_Small [mil]
  silkscreen extent -107,-93 107,92
IEC_HotSurface_Small [mil]
  silkscreen extent -107,-93 107,92
Keystone5002 [mil] "For Keystone 500x miniature loop terminals"
  round 80 hole 40: 1(0,0)
  silkscreen extent -52,-52 52,52
Keystone5003 [mil] "For Keystone 500x miniature loop terminals"
  round 80 hole 40: 1(0,0)
  silkscreen extent -52,-52 52,52
Keystone5010 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
Keystone5011 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
Keystone5012 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
Label_375x375 [mil] "Thermal Transfer Label"
  round 1 on Mech13: 0(0,0)
  silkscreen extent -188,-188 188,188
Label_650x200 [mil] "Thermal Transfer Label"
  round 1 on Mech13: 0(0,0)
  silkscreen extent -325,-100 325,100
MuRata_CSTNR [mm] "SMD, 3-Leads, Body 4.5x2mm, Pitch 1.5mm"
  rrect25% 0.4x2.6 smd: 1(-1.5,0) 2(0,0) 3(1.5,0)
PWP0024T-MFG [mm]
  rrect22% 1.5x0.45 smd paste+0 mask+0: 1(-2.9,3.575) 2(-2.9,2.925) 3(-2.9,2.275) 4(-2.9,1.625) 5(-2.9,0.975) 6(-2.9,0.325) 7(-2.9,-0.325) 8(-2.9,-0.975) 9(-2.9,-1.625) 10(-2.9,-2.275) 11(-2.9,-2.925) 12(-2.9,-3.575) 13(2.9,-3.575) 14(2.9,-2.925) 15(2.9,-2.275) 16(2.9,-1.625) 17(2.9,-0.975) 18(2.9,-0.325) 19(2.9,0.325) 20(2.9,0.975) 21(2.9,1.625) 22(2.9,2.275) 23(2.9,2.925) 24(2.9,3.575)
  rrect3% 3.4x7.8 smd paste-1000 mask+0: 25(0,0)
  silkscreen extent -4.32,-4.28 2.25,4.28
PZT0100A_N [mm] "QFP, 100-Leads, Body 14x14mm, Pitch 0.50mm, IPC Medium Density"
  oval 1.45x0.3 smd: 1(-7.725,6) 2(-7.725,5.5) 3(-7.725,5) 4(-7.725,4.5) 5(-7.725,4) 6(-7.725,3.5) 7(-7.725,3) 8(-7.725,2.5) 9(-7.725,2) 10(-7.725,1.5) 11(-7.725,1) 12(-7.725,0.5) 13(-7.725,0) 14(-7.725,-0.5) 15(-7.725,-1) 16(-7.725,-1.5) 17(-7.725,-2) 18(-7.725,-2.5) 19(-7.725,-3) 20(-7.725,-3.5) 21(-7.725,-4) 22(-7.725,-4.5) 23(-7.725,-5) 24(-7.725,-5.5) 25(-7.725,-6) 51(7.725,-6) 52(7.725,-5.5) 53(7.725,-5) 54(7.725,-4.5) 55(7.725,-4) 56(7.725,-3.5) 57(7.725,-3) 58(7.725,-2.5) 59(7.725,-2) 60(7.725,-1.5) 61(7.725,-1) 62(7.725,-0.5) 63(7.725,0) 64(7.725,0.5) 65(7.725,1) 66(7.725,1.5) 67(7.725,2) 68(7.725,2.5) 69(7.725,3) 70(7.725,3.5) 71(7.725,4) 72(7.725,4.5) 73(7.725,5) 74(7.725,5.5) 75(7.725,6)
  oval 0.3x1.45 smd: 26(-6,-7.725) 27(-5.5,-7.725) 28(-5,-7.725) 29(-4.5,-7.725) 30(-4,-7.725) 31(-3.5,-7.725) 32(-3,-7.725) 33(-2.5,-7.725) 34(-2,-7.725) 35(-1.5,-7.725) 36(-1,-7.725) 37(-0.5,-7.725) 38(0,-7.725) 39(0.5,-7.725) 40(1,-7.725) 41(1.5,-7.725) 42(2,-7.725) 43(2.5,-7.725) 44(3,-7.725) 45(3.5,-7.725) 46(4,-7.725) 47(4.5,-7.725) 48(5,-7.725) 49(5.5,-7.725) 50(6,-7.725) 76(6,7.725) 77(5.5,7.725) 78(5,7.725) 79(4.5,7.725) 80(4,7.725) 81(3.5,7.725) 82(3,7.725) 83(2.5,7.725) 84(2,7.725) 85(1.5,7.725) 86(1,7.725) 87(0.5,7.725) 88(0,7.725) 89(-0.5,7.725) 90(-1,7.725) 91(-1.5,7.725) 92(-2,7.725) 93(-2.5,7.725) 94(-3,7.725) 95(-3.5,7.725) 96(-4,7.725) 97(-4.5,7.725) 98(-5,7.725) 99(-5.5,7.725) 100(-6,7.725)
  silkscreen extent -8.1,-8.2 8.1,8.2
RGC0064B [mm] "VQFN-64"
  rrect42% 0.6x0.24 smd mask+0: 1(-4.4,3.75) 2(-4.4,3.25) 3(-4.4,2.75) 4(-4.4,2.25) 5(-4.4,1.75) 6(-4.4,1.25) 7(-4.4,0.75) 8(-4.4,0.25) 9(-4.4,-0.25) 10(-4.4,-0.75) 11(-4.4,-1.25) 12(-4.4,-1.75) 13(-4.4,-2.25) 14(-4.4,-2.75) 15(-4.4,-3.25) 16(-4.4,-3.75) 33(4.4,-3.75) 34(4.4,-3.25) 35(4.4,-2.75) 36(4.4,-2.25) 37(4.4,-1.75) 38(4.4,-1.25) 39(4.4,-0.75) 40(4.4,-0.25) 41(4.4,0.25) 42(4.4,0.75) 43(4.4,1.25) 44(4.4,1.75) 45(4.4,2.25) 46(4.4,2.75) 47(4.4,3.25) 48(4.4,3.75)
  rrect42% 0.24x0.6 smd mask+0: 17(-3.75,-4.4) 18(-3.25,-4.4) 19(-2.75,-4.4) 20(-2.25,-4.4) 21(-1.75,-4.4) 22(-1.25,-4.4) 23(-0.75,-4.4) 24(-0.25,-4.4) 25(0.25,-4.4) 26(0.75,-4.4) 27(1.25,-4.4) 28(1.75,-4.4) 29(2.25,-4.4) 30(2.75,-4.4) 31(3.25,-4.4) 32(3.75,-4.4) 49(3.75,4.4) 50(3.25,4.4) 51(2.75,4.4) 52(2.25,4.4) 53(1.75,4.4) 54(1.25,4.4) 55(0.75,4.4) 56(0.25,4.4) 57(-0.25,4.4) 58(-0.75,4.4) 59(-1.25,4.4) 60(-1.75,4.4) 61(-2.25,4.4) 62(-2.75,4.4) 63(-3.25,4.4) 64(-3.75,4.4)
  rrect2% 4.25x4.25 smd paste-2.112: 65(0,0)
Samtec_HTSW-102-07-G-S [mm] "Samtec 100mil, 1x2, 230 mil above insulator"
  rrect6% 1.65x1.65 hole 1.016: 1(-1.27,0)
  round 1.65 hole 1.016: 2(1.27,0)
  silkscreen extent -3.3,-1.27 2.54,1.27
SM_RADIAL_G [mm] "10 x 10.2mm:  Panasonic G"
  rect 4.1x2 smd: 1(-4.35,0) 2(4.35,0)
  silkscreen extent -5.35,-5.35 5.35,5.35
SOD-123 [mm] "On Semi recommended land pattern"
  rect 0.915x1.22 smd: 1(-1.637,0) 2(1.637,0)
  silkscreen extent -2.74,-1.17 2.03,1.17
SULLINS_PEC10DAAN [mm] "SULLINS"
  rrect50% 1.55x1.55 hole 1.016: 1(-1.27,11.43)
  round 1.55 hole 1.016: 2(1.27,11.43) 3(-1.27,8.89) 4(1.27,8.89) 5(-1.27,6.35) 6(1.27,6.35) 7(-1.27,3.81) 8(1.27,3.81) 9(-1.27,1.27) 10(1.27,1.27) 11(-1.27,-1.27) 12(1.27,-1.27) 13(-1.27,-3.81) 14(1.27,-3.81) 15(-1.27,-6.35) 16(1.27,-6.35) 17(-1.27,-8.89) 18(1.27,-8.89) 19(-1.27,-11.43) 20(1.27,-11.43)
  silkscreen extent -2.9,-12.7 2.54,12.7
TI_Stacked_Overlay_Small [mil]
TP_H045P075 [mm] "TP_H0.45P0.75"
  round 0.75 hole 0.45: 1(0,0)
WE-HCC_1210 [mm] "WURTH"
  rect 2.9x5.4 smd: 1(-4.95,0) 2(4.95,0)
  silkscreen extent -6,-5.9 6,5.9
WEEE_Minimum [mil] "WEEElie bin"
  silkscreen extent 22,-71 54,74
WL-SMCW_GREEN [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8
WL-SMCW_RED [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8
Wurth_60900213421 [mil] "Shunt, 2.54mm, Black"
  round 1 on Mech3: 0(0,0)
WURTH_61300311121 [mm] "Header, 2.54mm, 3x1, TH"
  rrect50% 1.65x1.65 hole 1.15: 1(-2.54,0)
  round 1.65 hole 1.15: 2(0,0) 3(2.54,0)
Wurth_61301421121 [mm] "Header, 2.54mm, 7x2, TH"
  rrect50% 1.65x1.65 hole 1.1: 1(-1.27,7.62)
  round 1.65 hole 1.1: 2(1.27,7.62) 3(-1.27,5.08) 4(1.27,5.08) 5(-1.27,2.54) 6(1.27,2.54) 7(-1.27,0) 8(1.27,0) 9(-1.27,-2.54) 10(1.27,-2.54) 11(-1.27,-5.08) 12(1.27,-5.08) 13(-1.27,-7.62) 14(1.27,-7.62)
XTAL_MS3V-T1R [mm] "Micro Crystal Switzerland recommended land pattern"
  rect 1.1x0.6 smd: 1(-2.775,0.45) 2(-2.775,-0.45)
  rect 2.4x1.5 smd: 3(2.775,0)
  silkscreen extent -1.9,-0.74 1.2,0.74

## Part data
C1 C2 C19 C55 C56 C57: library part CMP-0079993-1, "CAP, CERM, 0.01 µF, 100 V,+/- 10%, X7R, 0603"
C3 C4: library part CMP-2000-07531-4, "Ceramic Capacitor General Use 1uF ±10% 50V X7R 0603"
C5 C10: library part CMP-207839-000004-1, "CAP CER 0.1UF 50V X7R 0603"
C6 C15 C21 C25 C32 C33 C34 C36 C46 C48 C50 C52 C53 C54: library part CMP-0006837-4, "CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, 0603"
C7: library part CMP-0078153-1, "CAP, CERM, 22 µF, 10 V,+/- 20%, X5R, 0805"
C8 C11: library part CMP-1035-02321-3, "CAP CER 10000PF 50V X7R 0603"
C9: library part CMP-0090362-1, "0.1µF ±10% 10V Ceramic Capacitor X7R 0402 (1005 Metric)"
C12 C16: library part CMP-03020-030804-1, "CAP CER 1000PF 50V X7R 0603"
C13 C14: library part CMP-0011178-2, "CAP, AL, 150 uF, 50 V, +/- 20%, 0.18 ohm, AEC-Q200 Grade 2, SMD"
C17: library part CMP-0094458-1, "10µF ±20% 25V Ceramic Capacitor X5R 0603 (1608 Metric)"
C18: library part CMP-0008507-2, "CAP, CERM, 0.068 uF, 100 V, +/- 10%, X7R, 1206"
C20: library part CMP-0097305-1, "4.7 µF ±20% 10V Ceramic Capacitor X5R 0603 (1608 Metric)"
C22 C24: library part CMP-0097306-1, "33 pF ±5% 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric)"
C23 C41 C59: library part CMP-0097311-1, "1000 pF ±5% 100V Ceramic Capacitor C0G, NP0 0603 (1608 Metric)"
C26 C27 C42 C43 C44 C45: library part CMP-0006215-2, "CAP, CERM, 10 pF, 50 V, +/- 5%, C0G/NP0, 0402"
C28 C30 C47: library part CMP-0006830-4, "CAP, CERM, 0.22 uF, 16 V, +/- 10%, X7R, 0603"
C29 C49: library part CMP-0097608-1, "0.47 µF ±10% 16V Ceramic Capacitor X7R 0603 (1608 Metric)"
C31 C51: library part CMP-0097340-1, "Alum. Polymer Cap 10µF 10V 5.5mmV-Chip WCAP-PSLP Series Lifetime 2000h +105°C"
C35 C40: library part CMP-0006831-4, "CAP, CERM, 1 uF, 16 V, +/- 10%, X7R, 0603"
C37 C39: library part CMP-0006828-4, "CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0603"
C38: library part CMP-0006825-5, "CAP, CERM, 2.2 uF, 16 V, +/- 20%, X5R, 0603"
D1: library part CMP-0002893-1, "LED, Super Red, SMD"
D2: library part CMP-0002894-2, "LED, Green, SMD"
D5 D6 D8 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19: library part CMP-1426-00009-1, "SMD mono-color Chip LED, WL-SMCW, Bright Green"
D20: library part CMP-0077592-3, "Diode, Zener, 2.7 V, 500 mW, SOD-123"
F1: library part CMP-0084439-1, "Fuse, 3 A, 32VAC/VDC, SMD"
FID1 FID2 FID3: library part CMP-0077181-1, "Fiducial mark.  There is nothing to buy or mount."
J1 J3 J12 J13 J14 J16: library part CMP-1502-03256-1, "Series 101 - 5.00 mm Horizontal Entry Modular with Pressure Clamp WR-TBL, 2 pin"
J2 J4 J15 J17 J18 J21 J23: library part CMP-0075483-1, "Header, 100mil, 2x1, Gold, TH"
J5 J19: library part CMP-0086377-1, "Conn; Term Blk; PCB; Screw; 4; 5.08 mm; Front; 24-14 AWG; 16 A; 250 V; Solder"
J6: library part CMP-0054796-4, "Header, 2.54 mm, 3x1, Gold, TH"
J7: library part CMP-0054623-2, "Header, 2.54mm, 10x2, Tin, TH"
J8: library part CMP-0093233-2, "2 Position Wire to Board Terminal Block Horizontal with Board 0.250\" (6.35mm) Through Hole"
J9 J10: library part CMP-0086014-1, "Header, 2.54mm, 7x2, Gold, TH"
J11: library part CMP-0097752-1, "Conn Micro USB 2.0 Type AB RCP 5 POS 0.65mm Solder RA SMD 5 Terminal 1 Port T/R"
L1 L2: library part CMP-0003184-2, "Ferrite Bead, 140 ohm @ 100 MHz, 0.55 A, 0603"
L3: library part CMP-0063986-1, "Inductor, Shielded Drum Core, Ferrite, 1 uH, 24 A, 0.0012 ohm, SMD"
LBL1: library part CMP-0003625-1, "Thermal Transfer Printable Labels, 0.650\" W x 0.200\" H - 10,000 per roll"
LBL2: library part CMP-00007-1, "Harsh Environment Multi-Purpose Polyester Labels for 3\" Core Printers - 0.375\" x 0.375\", White"
Logo1: library part CMP-0074844-1
Logo2: library part CMP-0074838-1, "Texas Instrument Corporate Signature"
Logo3: library part CMP-0074847-1, "FCC_disclaimer"
Logo4: library part CMP-0074769-3
Logo5: library part CMP-0074836-1, "IEC 61010-1 Caution Warning"
LOGO6: library part CMP-0074837-2, "IEC 61010-1 Hot Surface Warning"
R1: library part CMP-0095262-1, "100 Ohms ±5% 0.2W, 1/5W Chip Resistor 0603 (1608 Metric) Automotive AEC-Q200, Moisture Resistant, Pulse Withstanding Thick Film"
R3 R4 R62 R63 R68: library part CMP-0025697-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603"
R9 R37 R64 R65 R66 R67: library part CMP-0097401-1, "Thick Film Resistors 0402 10O ±1% 0.125W"
R18 R19 R57: library part CMP-0026935-3, "RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R30 R31 R32 R39 R40 R41 R51 R52 R53 R54: library part CMP-0025886-5, "RES, 10 k, 5%, 0.1 W, 0603"
R43: library part CMP-0082533-1, "RES, 4.99 k, 1%, 0.1 W, 0603"
R45 R47 R48 R49 R80 R81 R82 R83 R84 R85 R86 R87 R88: library part CMP-0025785-4, "RES, 330, 5%, 0.1 W, AEC-Q200 Grade 0, 0603"
R55 R60: library part CMP-0026728-1, "RES, 220 k, 1%, 0.0625 W, 0402"
R56: library part CMP-0026190-2, "RES, 240 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R58: library part CMP-0025924-5, "RES, 470, 5%, 0.1 W, 0603"
R59: library part CMP-0025930-5, "RES, 560, 5%, 0.1 W, 0603"
R61: library part CMP-0026021-3, "RES, 150 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R72 R75: library part CMP-0026888-3, "RES, 27, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R76: library part CMP-0026085-3, "RES, 1.40 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R77: library part CMP-0026859-2, "RES, 1.0 M, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R78: library part CMP-0026907-3, "RES, 33 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R90 R91 R92 R93 R94 R95 R96: library part CMP-0026722-1, "RES, 100, 1%, 0.063 W, 0402"
R97: library part CMP-0023620-3, "RES, 91.0 k, 0.1%, 0.1 W, 0603"
R98: library part CMP-0023404-3, "RES, 10.0 k, 0.1%, 0.1 W, 0603"
S: library part CMP-1426-00010-2, "LED RED CLEAR 0805 SMD"
S1: library part CMP-0097347-1, "Tactile Switch SPST-NO Top Actuated Surface Mount"
SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J27 SH-J28 SH-J31 SH-J32 SH-J33 SH-J35 SH-J36: library part CMP-0003761-2, "Shunt, 2.54mm, Gold, Black"
TP1 TP4 TP6 TP8 TP13 TP35: library part CMP-0055148-2, "Test Point, Multipurpose, Black, TH"
TP2 TP9 TP10 TP12 TP14 TP17 TP18 VM VM_HS: library part CMP-0055147-2, "Test Point, Multipurpose, Red, TH"
TP3 TP5 TP7 TP11 TP15 TP16: library part CMP-0055149-2, "Test Point, Multipurpose, White, TH"
TP19 TP29 TP30 TP31 TP32 TP33 TP34: library part CMP-0003719-1, "Testpoint"
TP20 TP21 TP22 TP23 TP24 TP25 TP26 TP27 TP28: library part CMP-0055139-2, "Test Point, Miniature, White, TH"
TP36: library part CMP-0055140-2, "Test Point, Miniature, Orange, TH"
TP37 TP38 TP39: library part CMP-0075110-1, "1mm Uninsulated Shorting Plug, 10.16mm spacing, TH"
TP40 TP41: library part CMP-0055147-1, "Test Point, Multipurpose, Red, TH"
U1: library part CMP-0038879-1, "20 MHz Mixed Signal Microcontroller with 256 KB Flash, 18432 B SRAM and 74 GPIOs, -40 to 85 degC, 100-pin QFP (PZ), Green (RoHS & no Sb/Br)"
U2: library part CMP-0039269-4, "16-Bit Ultra-Low-Power Microcontroller, 128KB Flash, 8KB RAM, USB, 12Bit ADC, 2 USCIs, 32Bit HW MPY, RGC0064B (VQFN-64)"
U3: library part CMP-0036328-3, "500mA, Adjustable, Low Quiescent Current, Low-Noise, High-PSRR, Single-Output LDO Regulator, DRB0008A (VSON-8)"
U4: library part CMP-0070570-1, "Ultra-Low Quiescent Current Voltage Regulator, 8-pin Narrow SOIC, Pb-Free"
U5: library part CMP-0120419-1, "8-channel Configurable Low-side and High-side Driver for Automotive Relay, Lighting and Motor Control"
U6: library part CMP-0043099-3, "Low-Capacitance 2-Channel +/-15kV ESD Protection Array for High-Speed Data Interfaces, DRY0006A (USON-6)"
Y1: library part CMP-0085483-1, "Oscillator, 4 MHz, 700 ppm, 39 pF, SMD"
Y2: library part CMP-0004566-4, "Crystal, 32.768 kHz, 12.5pF, SMD"

## Via types
v1: diameter 24, hole 16, Top Layer to Bottom Layer, tented both sides, 195 vias
v2: diameter 24, hole 8, Top Layer to Bottom Layer, tented both sides, 53 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 21 vias
v4: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 16 vias
v5: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 11 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
CHANNEL_0: D15.2 U1.50 | length 1509.6
  Top Layer w8: v1@967.45,654.05 U1.50@967.45,706.86 ; D15.2@2101.08,884.11 2165.66,884.11 v1(2166.68,883.09)
  Bottom Layer w8: v1(967.78,653.73) 1314.04,1000 2049.78,1000 v1(2166.68,883.09)
CHANNEL_1: D19.2 U1.51 | length 1329
  Top Layer w8: U1.51@1035.37,774.78 1255.61,774.78 v1(1286.07,744.31) ; D19.2@2096.68,611.75 2096.73,611.31 v1(2101.07,569)
  Bottom Layer w8: v1(1286.07,744.31) 1317.48,712.9 1516.17,712.9 1588.07,641 1588.07,556 1678.07,466 1998.07,466 v1(2101.07,569)
CHANNEL_2: D14.2 U1.52 | length 1171.2
  Top Layer w8: U1.52@1035.37,794.46 1300.93,794.46 v1(1331.07,764.31) ; D14.2@1961.08,884.11 1962.1,883.09 v1(2031.68,883.09)
  Signal Layer 2 w8: v1(1331.07,764.31) 1364.76,798 1733.07,798 1869.07,934 1980.78,934 v1(2031.68,883.09)
CHANNEL_3: D18.2 U1.53 | length 1208.7
  Top Layer w8: U1.53@1035.37,814.15 1326.24,814.15 v1(1381.07,759.31) ; D18.2@1961.07,611.75 1966.07,606.75 v1(1966.07,574)
  Bottom Layer w8: v1(1381.07,759.31) 1403.76,782 1495.07,782 1608.07,669 1608.07,569 1677.07,500 1892.07,500 v1(1966.07,574)
CHANNEL_4: D13.2 U1.54 | length 1021.2
  Top Layer w8: U1.54@1035.37,833.83 1341.15,834.23 v1(1436.07,739.31) ; D13.2@1826.08,884.11 1890.66,884.11 v1(1891.68,883.09)
  Signal Layer 2 w8: v1(1436.07,739.31) 1716.39,739.31 1860.17,883.09 v1(1891.68,883.09)
CHANNEL_5: D17.2 U1.55 | length 1006.2
  Top Layer w8: U1.55@1035.37,853.52 1400.28,853.52 v1(1436.07,889.31) ; D17.2@1826.07,611.75 1831.07,606.75 v1(1831.07,574)
  Bottom Layer w8: v1(1436.07,889.31) 1558.76,889.31 1831.07,617 v1(1831.07,574)
CHANNEL_6: D12.2 U1.56 | length 837.8
  Top Layer w8: U1.56@1035.37,873.2 1344.96,873.2 v1(1386.07,914.31) ; D12.2@1686.08,884.11 1755.66,884.11 v1(1756.68,883.09)
  Bottom Layer w8: v1(1386.07,914.31) 1404.76,933 1706.78,933 v1(1756.68,883.09)
CHANNEL_7: D16.2 U1.57 | length 937.7
  Top Layer w8: U1.57@1035.37,892.89 1289.65,892.89 v1(1336.07,939.31) ; D16.2@1686.07,611.75 1691.07,606.75 v1(1691.07,574)
  Bottom Layer w8: v1(1336.07,939.31) 1336.07,897 1389.07,844 1501.07,844 1691.07,654 v1(1691.07,574)
DRV_STATUS: D11.2 U1.35 | length 691.5
  Top Layer w8: v1@672.18,654.05 U1.35@672.18,706.86
  Top Layer w10: D11.2@1197.01,468.33 v1(1197.01,531.04)
  Bottom Layer w8: v1(671.85,653.73) 711.59,614 885.07,614 917.07,582 1146.06,582 v1(1197.01,531.04)
EZFET_AVBUS: C24.2 R56.1 R61.2 U2.1 | length 558.2
  Top Layer w10: 371.07,2504 371.07,2452.38 U2.1@389.88,2433.57
  Top Layer w12: 371.07,2504 v1(425.31,2558.23)
  Top Layer w20: v1(436.07,2819) R61.2@404.7,2819 R56.1@404.7,2769 C24.2@461.39,2769
  Signal Layer 1 w12: v1(425.31,2558.23) 425.31,2804.98 436.07,2815.75 v1(436.07,2819)
EZFET_AVCC2ADC: C22.2 R55.1 R60.2 U2.2 | length 412.1
  Top Layer w10: 380.8,2414.19 381.11,2413.88 396.42,2413.88 U2.2@396.69,2413.61
  Top Layer w12: 380.8,2414.19 351.2,2443.79 351.2,2526.74 404.7,2580.24 R60.2@404.7,2669
  Top Layer w20: R60.2@404.7,2669 R55.1@404.7,2719 C22.2@461.39,2719
EZFET_D_N: C42.1 R72.2 U2.52 | length 644.6
  Top Layer w10: U2.52@658.5,2458.88 658.78,2459.16 658.78,2473.05 670.56,2484.83 681.64,2484.83 715.81,2519 1142.57,2519 1171.07,2547.5 1171.07,2561.64 1165.22,2567.5 1160.92,2567.5 1156.07,2572.34 R72.2@1156.07,2574.31 1110.01,2574.31 C42.1@1106.07,2570.37
EZFET_D_P: C43.1 R75.2 R76.1 R77.2 U2.50 | length 720.9
  Top Layer w10: U2.50@697.87,2458.88 697.87,2472.78 724.09,2499 856.49,2499 ; R76.1@856.07,2453.68 856.07,2490.49 856.49,2490.91 856.49,2499 ; R77.2@931.07,2453.68 931.07,2490.49 931.21,2490.63 931.21,2499 ; C43.1@1256.07,2570.37 1252.14,2574.31 R75.2@1206.07,2574.31 1206.07,2572.34 1201.23,2567.5 1196.93,2567.5 1191.07,2561.64 1191.07,2539.22 1150.86,2499 931.21,2499 ; 856.49,2499 931.21,2499
EZFET_LED0: R58.1 U2.20 | length 178.5
  Top Layer w10: R58.1@381.07,1975.49 381.07,1976.48 481.34,2076.74 U2.20@481.34,2112.43
EZFET_LED1: R59.1 U2.21 | length 155.6
  Top Layer w10: R59.1@456.07,1975.49 456.07,1976.48 501.02,2021.43 U2.21@501.02,2112.43
EZFET_PUR: R76.2 U2.51 | length 222.7
  Top Layer w10: v1(676.07,2419) 676.07,2446 677.91,2447.83 677.91,2458.61 U2.51@678.19,2458.88
  Top Layer w12: v1(826.07,2419) 828.37,2416.7 853.69,2416.7 R76.2@856.07,2414.31
  Signal Layer 2 w12: v1(676.07,2419) v1(826.07,2419)
EZFET_RST: C23.2 J9.11 R57.1 U2.64 | length 1041.5
  Top Layer w8: v1(401.07,2489) 401.07,2487.18 422.28,2465.97 U2.64@422.28,2458.88
  Top Layer w12: J9.11@339.5,3111.4 393.15,3057.75 393.15,2964.89 404.7,2953.34 R57.1@404.7,2869 C23.2@451.55,2869
  Signal Layer 1 w12: J9.11@339.5,3111.4 293.15,3065.05 293.15,2928.52 345.96,2875.7 345.96,2544.11 v1(401.07,2489)
EZFET_TCK: J9.7 U2.63 | length 841.5
  Top Layer w8: v1(441.07,2424) 441.52,2424.44 441.52,2458.44 U2.63@441.97,2458.88
  Signal Layer 1 w12: v1(441.07,2424) 441.07,2477.4 435.2,2483.28 435.2,2491.46 393.15,2533.52 393.15,3030.6 427.59,3065.05 493.15,3065.05 J9.7@539.5,3111.4
EZFET_TDI: J9.3 U2.61 | length 829.4
  Top Layer w8: v1(481.07,2424) 481.21,2424.13 481.21,2458.75 U2.61@481.34,2458.88
  Bottom Layer w10: v1(481.07,2424) 481.07,2478.82 485.95,2483.69 485.95,2653.87 684.85,2852.78 684.85,3056.75 J9.3@739.5,3111.4
EZFET_TDO: J9.1 U2.60 | length 795.9
  Top Layer w8: U2.60@501.02,2458.88 501.02,2481.92 511.07,2491.97 v1(511.07,2494)
  Bottom Layer w10: v1(511.07,2494) 511.07,2497.78 507.2,2501.66 507.2,2550.12 784.85,2827.78 784.85,3056.75 J9.1@839.5,3111.4
EZFET_TEST: J9.8 U2.59 | length 635.2
  Top Layer w8: v1@520.71,2424.36 520.89,2424.55 520.89,2458.7 U2.59@520.71,2458.88
  Signal Layer 1 w15: v1(521.07,2424) 521.07,2426.43 546.07,2451.43 546.07,3004.83 J9.8@539.5,3011.4
EZFET_TMS: J9.5 U2.62 | length 765.1
  Top Layer w8: v1(461.07,2494) 461.36,2493.71 461.36,2459.17 U2.62@461.65,2458.88
  Signal Layer 1 w12: v1(461.07,2494) 486.07,2519 486.07,3023.53 527.59,3065.05 593.15,3065.05 J9.5@639.5,3111.4
EZFET_UARTRXD: R66.1 U2.38 | length 386.5
  Top Layer w10: R66.1@681.07,1936.71 683.95,1939.59 685.92,1939.59 702.65,1956.32 708.4,1956.32 v1(711.07,1959) ; U2.38@743.15,2236.44 774.97,2236.44 782.41,2229 v1(786.2,2229)
  Signal Layer 1 w10: v1(711.07,1959) 711.07,2153.87 v1(786.2,2229)
EZFET_UARTTXD: R67.1 U2.37 | length 358.5
  Top Layer w10: R67.1@606.07,1936.71 608.95,1939.59 610.92,1939.59 627.65,1956.32 633.4,1956.32 v1(636.07,1959) ; v1(711.07,2214) 713.56,2216.48 742.87,2216.48 U2.37@743.15,2216.76
  Signal Layer 1 w10: v1(636.07,1959) 636.07,2139 v1(711.07,2214)
EZFET_USB_Shield: C47.1 J11.6 J11.7 J11.8 J11.9 J11.10 J11.11 R78.2 | length 172.9
  Top Layer w10: v1(1373.07,3026.41) 1446.11,3026.41 C47.1@1453.52,3019 ; v1(1373.23,3065.16) 1457.24,3065.16 R78.2@1461.07,3069
  other v1: 991.07,3026 991.23,3064.75
EZFET_V18: C28.1 U2.55 | length 158.3
  Top Layer w10: U2.55@599.45,2458.88 599.72,2459.16 599.72,2473.05 674.49,2547.81 692.37,2547.81 706.07,2561.52 C28.1@706.07,2562.5
EZFET_VBUS: C20.2 C21.1 C35.1 C36.1 C37.1 C48.2 L1.2 R56.2 U2.53 U3.5 U3.8 U6.1 | length 2287.9
  Top Layer w8: v1(636.07,2419) 638.09,2421.02 638.09,2458.16 U2.53@638.82,2458.88
  Top Layer w12: U3.8@967.69,2824.11 967.69,2848.88 974.72,2855.91 1044.46,2855.91
  Top Layer w15: C48.2@856.07,2837.5 869.46,2824.11 876.06,2824.11 U3.8@967.69,2824.11 ; U3.5@1044.46,2824.11 1044.46,2855.91 1050.39,2861.83 1050.39,2877.8 1061.59,2889 C37.1@1062.57,2889 1065.85,2892.27 1104.35,2892.27 v1(1106.07,2894) 1141.32,2894 1150.11,2902.78 U6.1@1150.11,2909
  Top Layer w20: v1(319.02,2769) R56.2@357.45,2769 ; C35.1@631.08,2845.37 631.08,2804 v1(666.07,2769) 666.84,2769.76 700.34,2769.76 C36.1@706.07,2775.49 ; C20.2@1331.07,2744 1334.32,2747.24 1334.32,2815.75 1331.07,2819 1331.07,2895.92 ; L1.2@1333.63,2944 1331.07,2941.44 1331.07,2895.92 ; v1(1356.07,2894) 1355.31,2894.76 1332.24,2894.76 1331.07,2895.92
  Signal Layer 1 w15: v1(636.07,2419) 636.07,2739 v1(666.07,2769)
  Signal Layer 2 w20: v1(319.02,2769) v1(666.07,2769) 823.57,2769 948.57,2894 v1(1106.07,2894) v1(1356.07,2894)
EZFET_VCC: C31.2 C32.1 C33.1 C34.1 J2.1 J10.9 R55.2 R57.2 R62.2 R63.2 R68.1 U2.11 U2.15 U2.40 | length 3676
  Top Layer w10: C32.1@262.57,2219 272.57,2209 v1(346.07,2209) ; U2.15@396.69,2157.7 369.88,2157.7 346.07,2181.51 v1(346.07,2209) ; U2.11@396.69,2236.44 396.42,2236.17 373.24,2236.17 v1(346.07,2209) ; U2.40@743.15,2275.81 808.71,2275.81
  Top Layer w15: R62.2@706.07,2841.44 781.07,2841.44 C33.1@781.07,2775.49 783.04,2773.52 854.11,2773.52 R68.1@856.07,2771.56 ; 808.71,2275.81 816.53,2267.99 861.21,2267.99 C31.2@885.21,2244
  Top Layer w20: v1(286.07,2719) R55.2@357.45,2719 ; v1(316.07,2869) R57.2@357.45,2869 ; C34.1@531.07,1912.5 531.07,1862.81 556.47,1837.42 556.47,1787.62 J10.9@565.07,1779.01 ; R63.2@781.07,2841.44 786.82,2847.19 787.81,2847.19 798.85,2858.23 815.31,2858.23 v1(816.07,2859) ; v1(846.07,2184) 846.07,2222.5 867.57,2244 C31.2@885.21,2244
  Signal Layer 1 w20: v1(316.07,2869) 286.07,2839 286.07,2269 v1(346.07,2209) 346.07,2001.24 565.07,1782.24 J10.9@565.07,1779.01
  Signal Layer 2 w20: v1(316.07,2869) 804.99,2869 814.99,2859 v1(816.07,2859) ; v1(346.07,2209) 390.95,2164.12 825.12,2164.12 844.99,2184 v1(846.07,2184)
  Bottom Layer w10: J2.1@166.07,1749 301.39,1749 320.78,1729.61 515.67,1729.61 J10.9@565.07,1779.01
EZFET_Vcore: C29.2 U2.17 | length 174.8
  Top Layer w12: 365.87,2112.43 U2.17@422.28,2112.43
  Top Layer w15: C29.2@260.6,2144 334.3,2144 365.87,2112.43
EZFET_VREF: C25.1 U2.9 | length 141.7
  Top Layer w12: C25.1@262.57,2294 318.13,2294 336.31,2275.81 U2.9@396.69,2275.81
EZFET_VUSB: C30.1 U2.54 | length 293.9
  Top Layer w10: v1(596.07,2419) 618.86,2441.78 618.86,2458.61 U2.54@619.13,2458.88 ; v1(745.31,2558.23) 776.81,2558.23 C30.1@781.07,2562.5
  Bottom Layer w10: v1(596.07,2419) 732.63,2555.55 742.63,2555.55 v1(745.31,2558.23)
EZFET_XT2IN: U2.57 Y1.1 | length 146.9
  Top Layer w10: U2.57@560.08,2458.88 560.08,2485.69 608.89,2534.5 612.61,2534.5 615.49,2537.38 Y1.1@615.49,2580.69
EZFET_XT2OUT: U2.58 Y1.3 | length 142.8
  Top Layer w10: Y1.3@497.38,2580.69 497.38,2537.38 500.25,2534.5 505.74,2534.5 540.39,2499.86 U2.58@540.39,2458.88
FAULT_STATUS: S.2 U1.36 | length 1005.6
  Top Layer w8: v1(1341.07,629) 1361.07,609 S.2@1361.07,470.33
  Top Layer w10: v1@677.03,802.05 691.86,787.22 U1.36@691.86,706.86
  Signal Layer 2 w10: v1(677.03,805.84) 1077.23,805.84 1254.07,629 v1(1341.07,629)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.1 C9.2 C10.2 C11.1 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.1 C21.2 C22.1 C23.1 C24.1 C25.2 C26.1 C27.1 C28.2 C29.1 C30.2 C31.1 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.1 C42.2 C43.2 C44.2 C45.2 C46.1 C47.2 C48.1 C49.1 C50.2 C51.1 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C59.1 D1.1 D2.1 D20.2 J1.2 J3.2 J5.4 J7.2 J8.1 J9.9 J10.13 J10.14 J12.2 J13.2 J17.2 J19.4 J23.2 L2.2 R30.2 R32.2 R43.1 R45.1 R47.1 R48.1 R49.1 R51.2 R52.2 R53.2 R60.1 R61.1 R77.1 R78.1 R80.1 R81.1 R82.1 R83.1 R84.1 R85.1 R86.1 R87.1 R88.1 R98.1 S1.3 S1.4 TP1.1 TP4.1 TP6.1 TP8.1 TP13.1 TP35.1 TP37.1 TP37.2 TP38.1 TP38.2 TP39.1 TP39.2 U1.10 U1.12 U1.15 U1.26 U1.29 U1.63 U1.76 U1.83 U1.90 U2.14 U2.16 U2.39 U2.49 U2.56 U2.65 U3.4 U3.9 U4.2 U4.3 U4.4 U4.5 U4.6 U4.7 U5.5 U5.25 U6.4 Y1.2 Y2.3 | length 2361.1
  Top Layer w8: v1(196.07,949) 242.45,949 C44.2@247.45,944 ; v1(983.27,1011) U1.63@1035.37,1011 ; v3(3228.83,1756.24) v3(3276.07,1756.24) ; U5.25@3233.26,1751.81 U5.25@3237.69,1747.38 ; v3(3276.07,1661.75) U5.25@3318,1745.61 ; U5.25@3279.99,1752.32 v3(3276.07,1756.24) ; U5.25@3313.54,1756.24 v3(3276.07,1709) 3271.71,1746.41 3280.88,1748.56 3284.66,1749.45 3280.39,1752.83 v3(3276.07,1756.24) ; U5.5@3314.46,1823.17 U5.25@3314.46,1756.24 ; U5.25@3376.07,1674 3385.44,1683.37 C9.2@3491.07,1683.37 ; U5.25@3314.46,1756.24 3314.46,1747.38 v3(3323.32,1756.24) U5.25@3314.46,1756.24
  Top Layer w10: U2.16@396.69,2138.02 396.97,2138.29 410.86,2138.29 448.4,2175.83 448.4,2191.32 v1(451.07,2194) ; U2.14@396.69,2177.39 430.68,2177.39 v1@447.29,2194 ; U1.15@427.1,971.63 427.45,971.97 456.96,971.97 493.67,1008.69 493.67,1031.6 v1(496.07,1034) ; U1.12@427.1,1030.68 488.97,1030.68 492.29,1034 v1(496.07,1034) ; U1.10@427.1,1070.05 483.34,1070.05 484.61,1071.32 485.17,1071.32 486.78,1069.7 v1(491.07,1074) ; C49.1@461.49,629.9 495.01,663.42 U1.26@495.01,706.86 495.36,707.21 495.36,736.72 514.96,756.32 523.4,756.32 v1(526.07,759) 528.75,756.32 534.12,756.32 553.72,736.72 553.72,707.21 U1.29@554.07,706.86 ; v1@486.33,1068.75 493.4,1061.67 493.4,1036.67 v1(496.07,1034) ; U2.65@569.92,2285.65 571.2,2286.94 571.2,2429.3 579.76,2437.86 U2.56@579.76,2458.88 ; v1(615.15,1384.31) 615.15,1388.1 622.37,1395.32 622.37,1403.8 C54.2@636.07,1417.5 636.07,1412.13 650.7,1397.5 651.68,1397.5 691.86,1357.32 U1.90@691.86,1315.13 ; v1(676.07,2259) 678.94,2256.13 U2.39@743.15,2256.13 ; U2.49@717.56,2458.88 U2.49@717.56,2458.88 746.02,2458.94 v1(746.07,2459) ; U1.83@829.66,1315.13 829.66,1269.2 841.07,1257.78 v1(841.07,1254) ; U1.76@967.45,1315.13 967.45,1314.83 968.29,1314 v1(996.07,1314) ; U3.4@1044.46,2713.88 1044.46,2719.59 1045.56,2720.69 1058.98,2720.69 1062.29,2724 v1(1066.07,2724) ; U6.4@1191.07,2932.62 1191.07,2934.59 1197.59,2941.1 1197.59,2946.24 v1(1200.26,2948.92)
  Top Layer w20: C40.2@931.07,2625.49 v1(931.07,2669) ; C39.2@1006.07,2562.5 1049.58,2562.5 v1(1056.07,2569) ; v1(1756.34,608.15) 1756.51,608.32 R85.1@1756.51,640.36 ; R81.1@1756.86,745.36 1788.89,745.36 v1(1789.07,745.19) ; v1(1901.34,608.15) 1901.51,608.32 R86.1@1901.51,640.36 ; R82.1@1901.86,745.36 1933.89,745.36 v1(1934.07,745.19) ; v1(2036.34,608.15) 2036.51,608.32 R87.1@2036.51,640.36 ; R83.1@2036.86,745.36 2068.89,745.36 v1(2069.07,745.19) ; v1(2139.3,745.87) 2139.48,745.7 R84.1@2171.51,745.7 ; v1(2171.34,608.15) 2171.51,608.32 R88.1@2171.51,640.36 ; v2(3405.07,2137) 3405.57,2137.49 3405.57,2169.25 R43.1@3406.06,2169.74 ; v2(4069.1,2098.51) C3.2@4069.1,2132.11 ; v2(4146.07,2092.09) C5.2@4146.07,2125.69 ; v2(4226.07,2092.09) C11.1@4226.07,2125.69 ; v2(4306.07,2098) C12.2@4306.07,2131.59
  other v1: 720.07,225 1236.07,254 1081.07,259 1411.07,259 271.07,509 278.07,711 156.07,764 161.07,864 671.07,1089 211.07,1129 181.07,1344 1641.07,1734 901.07,1859 646.07,1864 751.07,1864 566.07,1974 866.07,1974 576.07,2019 1331.07,2019 186.07,2109 1201.07,2114 186.07,2174 1026.07,2199 1116.07,2244 186.07,2254 1026.07,2289 456.07,2359 686.07,2359 135.07,2526 232.07,2526 746.07,2619 458.07,2663 1106.07,2664 1256.07,2664 746.07,2669 518.7,2739 925.31,2768.23 1271.07,2779 1101.07,2804 316.07,2819 516.07,2819 591.07,2899 711.07,2944 956.07,2944 1415.07,2960 906.08,2969 1511.07,2979 1561.07,3019 1526.07,3069 1446.07,3139
  other v2: 2907.09,814.17 3057.09,864.17 3057.09,964.17 3057.09,1114.17 3057.09,1214.17 4031.07,1324 4207.09,1364.17 4157.09,1414.17 4257.09,1414.17 3429.57,1468.55 3471.07,1934 4439.07,2281
  other v3: 3134.34,1661.75 3181.59,1661.75 3228.83,1661.75 3323.32,1661.75 3370.56,1661.75 3417.81,1661.75 3134.34,1709 3181.59,1709 3228.83,1709 3323.32,1709 3370.56,1709 3417.81,1709 3134.34,1756.24 3181.59,1756.24 3370.56,1756.24 3417.81,1756.24
  other v4: 542.56,2211.84 597.28,2211.84 496.1,2258.29 542.56,2258.29 597.28,2258.29 643.74,2258.29 496.1,2313.02 542.56,2313.02 597.28,2313.02 643.74,2313.02 542.56,2359.47 597.28,2359.47 1006.07,2749.31 981.47,2769 1030.68,2769 1006.07,2788.68
GUI_STATUS: D10.2 U1.34 | length 709.4
  Top Layer w8: U1.34@652.49,706.86 v1@652.49,759.67
  Top Layer w10: D10.2@1038.12,468.33 v1(1038.12,531.04)
  Bottom Layer w10: v1(652.81,760) 622.07,729.26 622.07,640 684.07,578 867.07,578 914.03,531.04 v1(1038.12,531.04)
ID0: R39.2 R51.1 U1.43 | length 1036.3
  Top Layer w8: v1(806.07,773) 829.66,749.41 U1.43@829.66,706.86 ; v1(1101.07,1489) 1103.76,1489 1113.76,1479 1171.07,1479 ; R51.1@1171.07,1456.56 R39.2@1171.07,1501.44
  Bottom Layer w8: v1(806.07,773) 806.07,985.34 1104.95,1284.21 1104.95,1485.12 v1(1101.07,1489)
ID1: R40.2 R52.1 U1.44 | length 1132.3
  Top Layer w8: v1@849.34,654.05 U1.44@849.34,706.86 ; v1(1216.07,1479) 1254.56,1479 1258.28,1475.28 ; R52.1@1258.28,1451.56 1258.28,1475.28 ; R40.2@1258.28,1499 1258.28,1475.28
  Bottom Layer w8: v1(849.67,653.73) 845.21,658.18 845.21,660.3 836.07,669.44 836.07,989.68 1216.07,1369.68 v1(1216.07,1479)
ID2: R41.2 R53.1 U1.45 | length 1038.8
  Top Layer w8: U1.45@869.03,706.86 v1@869.03,759.67 ; v1(1301.07,1479) 1340.54,1479 1341.07,1478.46 ; R53.1@1341.07,1454.74 1341.07,1478.46 ; R41.2@1341.07,1502.19 1341.07,1478.46
  Bottom Layer w8: v1(868.7,760) 868.46,760.24 868.46,999.61 1301.07,1432.23 v1(1301.07,1479)
ID3: R30.1 R54.2 U1.46 | length 1187.1
  Top Layer w8: v1@888.71,654.05 U1.46@888.71,706.86 ; v1(1381.07,1479) 1424.05,1479 1426.07,1476.97 ; R30.1@1426.07,1453.25 1426.07,1476.97 ; R54.2@1426.07,1500.69 1426.07,1476.97
  Bottom Layer w8: v1(889.04,653.73) 902.07,666.77 902.07,804 887.7,818.37 887.7,985.62 v1(1381.07,1479)
ID4: R31.2 R32.1 U1.47 | length 1156.9
  Top Layer w8: U1.47@908.4,706.86 908.4,746.32 v1(932.07,770) ; v1(1471.07,1479) 1518.63,1479 1521.07,1481.44 ; R32.1@1521.07,1459 1521.07,1481.44 ; R31.2@1521.07,1503.88 1521.07,1481.44
  Bottom Layer w8: v1(932.07,770) 932.07,815 903.57,843.5 903.57,966.5 1356.07,1419 1411.07,1419 v1(1471.07,1479)
IN0: J7.5 TP22.1 U5.23 | length 1708
  Top Layer w8: J7.5@2031.07,1384 TP22.1@2162.73,1364 2341.07,1364 2360.36,1364 v1(2387.48,1364) v1@2396.07,1364 ; U5.23@3391.23,1596.59 3391.23,1555.51 v1(3427.75,1519)
  Signal Layer 2 w8: v1(2387.48,1364) 2387.48,1453.4 2493.07,1559 2600.07,1559 2711.07,1448 3356.75,1448 v1(3427.75,1519)
IN0_MCU: R94.1 U1.69 | length 416.8
  Top Layer w8: U1.69@1035.37,1129.11 1228.92,1129.11 1304.04,1054 R94.1@1421.07,1054
IN1: J7.7 TP23.1 U5.22 | length 1578
  Top Layer w8: J7.7@2031.07,1484 2152.73,1484 TP23.1@2167.73,1499 2170.23,1496.5 2373.57,1496.5 v1(2376.07,1494) ; U5.22@3365.64,1596.59 3365.86,1596.38 3365.86,1544.4 v1(3391.26,1519)
  Signal Layer 2 w8: v1(2376.07,1494) 2495.07,1613 2593.07,1613 2727.07,1479 3351.26,1479 v1(3391.26,1519)
IN1_MCU: R95.1 U1.70 | length 406.3
  Top Layer w8: U1.70@1035.37,1148.79 1248.73,1148.79 1298.52,1099 R95.1@1421.07,1099
MCU_3V3: C46.2 C51.2 C52.1 C53.1 C54.1 D5.2 J2.2 J7.4 J10.10 R9.2 R18.1 R19.2 R31.1 R37.1 R39.1 R40.1 R41.1 R54.1 TP36.1 U1.25 U1.64 U1.87 U1.89 | length 8594.5
  Top Layer w8: v1(966.07,1209) 966.07,1066.29 1001.68,1030.68 U1.64@1035.37,1030.68 ; v1(1136.07,1584.15) 1163.67,1556.56 R39.1@1171.07,1556.56 ; v1(1221.5,1584.15) 1251.53,1554.11 R40.1@1258.28,1554.11 ; v1(1300.04,1584.15) 1326.89,1557.3 R41.1@1341.07,1557.3 ; v1(1389.76,1584.15) 1418.1,1555.81 R54.1@1426.07,1555.81 ; R31.1@1521.07,1559 1576.07,1614 v1(1576.07,1619)
  Top Layer w10: v1(181.07,1219) 201.23,1239.15 235.48,1239.15 238.36,1242.03 R9.2@238.36,1294 ; 334.59,752.47 365.28,752.47 v1(367.41,750.34) 391.26,774.18 402.59,774.18 402.83,774.43 426.75,774.43 U1.25@427.1,774.78 ; C54.1@636.07,1480.49 641.39,1475.18 670.7,1475.18 ; v1(695.31,1183.08) 697.99,1185.76 707.89,1185.76 750.95,1228.82 750.95,1260.22 750.92,1314.29 750.57,1314.64 750.57,1344.99 739.01,1356.55 714.9,1356.55 711.89,1353.54 711.89,1315.48 U1.89@711.55,1315.13 ; 710.93,1356.55 710.93,1375.7 671.64,1414.99 671.64,1474.24 670.7,1475.18 ; R18.1@731.07,1467.62 731.07,1468.37 724.26,1475.18 670.7,1475.18
  Top Layer w15: C51.2@283.92,814.4 303.6,814.4 334.59,783.41 334.59,752.47 C53.1@334.59,674.92 C52.1@334.59,613.31 C46.2@334.59,552.23 334.59,494.48 358.26,470.81 D5.2@402.87,470.81 454.26,470.81 496.45,428.62 496.45,283.62 636.07,144 776.07,144 925.07,293 925.07,505 1113.57,693.5 1460.57,693.5 1496.07,729 1496.07,954 1826.07,1284 J7.4@1931.07,1284 ; TP36.1@426.07,1504 J10.10@565.07,1679.01 637,1607.09 637,1480.49 C54.1@636.07,1480.49 ; v1(1506.07,2054) 1646.07,2194 1646.07,2519.11 1607.56,2557.62 R19.2@1586.07,2557.62
  Signal Layer 1 w10: v1(966.07,1209) 966.07,1378.82 1051.07,1463.82 1051.07,1499.15 1132.13,1580.21 v1@1136.07,1580.21 ; v1@1141.07,1580.21 v1@1141.07,1584
  Signal Layer 1 w15: v1(1506.07,2054) 1576.07,1984 v1(1576.07,1619)
  Signal Layer 2 w12: v1(181.07,1219) 420.24,1219 456.15,1183.08 v1(695.31,1183.08)
  Signal Layer 2 w15: J10.10@565.07,1679.01 660.09,1584 v1@1136.07,1584
  Bottom Layer w10: J2.2@166.07,1649 311.08,1504 TP36.1@426.07,1504 ; v1(181.07,1219) 181.07,1157.71 173.18,1149.82 173.18,1092.33 390.95,874.56 390.95,773.87 v1(367.41,750.34) ; v1(1136.07,1584.15) v1(1221.5,1584.15) v1(1300.04,1584.15) v1(1389.76,1584.15) 1541.23,1584.15 v1(1576.07,1619)
MCU_STATUS: D8.2 TP19.1 U1.37 | length 327
  Top Layer w8: U1.37@711.55,706.86 711.55,659.52 720.33,650.74 D8.2@720.33,469.33 TP19.1@806.07,474
MCU_UARTRXD: J10.8 U1.61 | length 888.2
  Top Layer w8: v1(806.07,1198.78) 806.07,1154.15 988.6,971.63
  Top Layer w10: J10.8@665.07,1679.01 803.4,1540.69 803.4,1516.67 v1(806.07,1514) ; 988.6,971.63 U1.61@1035.37,971.63
  Signal Layer 1 w10: v1(806.07,1198.78) v1(806.07,1514)
MCU_UARTTXD: J10.6 U1.60 | length 950.1
  Top Layer w8: v1(806.07,1119) 973.09,951.95
  Top Layer w10: 973.09,951.95 U1.60@1035.36,951.95
  Signal Layer 1 w10: J10.6@765.07,1679.01 886.2,1557.89 886.2,1292.82 896.15,1282.87 896.15,1209.07 v1(806.07,1119)
NetC15_1: C15.1 R9.1 U1.9 | length 365.8
  Top Layer w10: C15.1@287.57,1369 287.57,1309.74 273.79,1295.96 276.67,1293.09 276.67,1289.15 336.95,1228.87 336.95,1150.37 397.24,1090.08 426.75,1090.08 U1.9@427.1,1089.74
NetC26_2: C26.2 J10.1 R64.2 | length 211
  Top Layer w10: C26.2@906.08,1920.37 960.01,1920.37 976.23,1904.15 978.2,1904.15 R64.2@981.07,1901.28 ; J10.1@965.07,1779.01 965.07,1887.25 R64.2@979.11,1901.28
NetC27_2: C27.2 J10.3 R65.2 | length 236.7
  Top Layer w10: R65.2@756.07,1901.28 815.92,1901.28 C27.2@831.07,1916.44 ; C27.2@831.07,1920.37 C27.2@831.07,1916.44 ; J10.3@865.07,1779.01 831.07,1813.01 C27.2@831.07,1916.44
NetC38_1: C38.1 C40.1 R68.2 U3.1 | length 360.6
  Top Layer w12: R68.2@856.07,2716.44 857.06,2716.44 858.34,2715.16 856.88,2713.7 856.88,2682.69 891.42,2648.15 891.42,2562.5
  Top Layer w15: C38.1@856.07,2562.5 891.42,2562.5 926.76,2562.5 931.08,2566.81 C40.1@931.08,2570.37 ; R68.2@858.34,2715.16 966.41,2715.16 U3.1@967.69,2713.88
NetC39_1: C39.1 U3.3 | length 101.6
  Top Layer w12: C39.1@1006.07,2617.62 1006.07,2661.32 1018.87,2674.11 U3.3@1018.87,2713.88
NetC44_1: C44.1 U1.14 Y2.1 | length 180.7
  Top Layer w8: C44.1@294.7,944 294.7,980.31 314.61,1000.23 Y2.1@355.87,1000.23 364.79,991.31 U1.14@427.1,991.31
NetC45_1: C45.1 U1.13 Y2.2 | length 192.8
  Top Layer w10: C45.1@279.7,1094 279.7,1075.18 319.22,1035.66 Y2.2@355.87,1035.66 372.11,1035.66 396.43,1011.34 426.73,1011.34 U1.13@427.1,1011
NetC49_2: C49.2 U1.27 | length 79.4
  Top Layer w10: U1.27@514.7,706.86 515.04,706.52 515.04,635.4 C49.2@520.54,629.9
NetC50_1: C50.1 R37.2 U1.11 | length 275
  Top Layer w10: R37.2@273.79,1244 273.79,1217.82 287.57,1204.04 C50.1@287.57,1169 288.56,1169 349.75,1107.8 349.75,1098.2 397.24,1050.71 426.75,1050.71 U1.11@427.1,1050.37
NetD1_2: D1.2 R58.2 | length 659.7
  Top Layer w10: v1(246.07,2429) 247.57,2429 D1.2@281.07,2462.5 ; v1(336.07,1904) 339.86,1904 348.37,1912.5 R58.2@381.07,1912.5
  Signal Layer 1 w10: v1(246.07,2429) 246.07,1994 v1(336.07,1904)
NetD2_2: D2.2 R59.2 | length 740.9
  Top Layer w10: D2.2@181.07,2462.5 211.07,2432.5 v1(211.07,2429) ; v1(431.07,1874) 433.75,1876.67 433.75,1889.19 456.07,1911.52 R59.2@456.07,1912.5
  Bottom Layer w10: v1(211.07,2429) 211.07,2094 v1(431.07,1874)
NetD5_1: D5.1 R49.2 | length 77.5
  Top Layer w25: R49.2@402.53,320.62 402.7,320.79 402.7,397.81 D5.1@402.87,397.98
NetD6_1: D6.1 R43.2 | length 77.3
  Top Layer w25: R43.2@3406.07,2228.81 D6.1@3406.07,2306.09
NetD8_1: D8.1 R45.2 | length 78.3
  Top Layer w25: R45.2@720.32,318.15 720.32,396.43 D8.1@720.37,396.47
NetD10_1: D10.1 R47.2 | length 78.3
  Top Layer w25: R47.2@1038.11,317.15 1038.11,395.42 D10.1@1038.15,395.47
NetD11_1: D11.1 R48.2 | length 78
  Top Layer w25: D11.1@1196.46,394.91 1197,394.37 R48.2@1197,317.15
NetD12_1: D12.1 R81.2 | length 72
  Top Layer w8: D12.1@1686.08,801.44 R81.2@1758.06,802.63
NetD13_1: D13.1 R82.2 | length 69
  Top Layer w8: D13.1@1826.08,801.44 R82.2@1895.03,801.44
NetD14_1: D14.1 R83.2 | length 71.3
  Top Layer w8: D14.1@1961.08,801.44 2030.03,801.44 R83.2@2031.68,803.09
NetD15_1: D15.1 R84.2 | length 64
  Top Layer w8: D15.1@2101.08,801.44 R84.2@2165.03,801.44
NetD16_1: D16.1 R85.2 | length 63.7
  Top Layer w8: D16.1@1686.68,694.43 R85.2@1750.35,694.43
NetD17_1: D17.1 R86.2 | length 63.7
  Top Layer w8: D17.1@1821.68,694.43 R86.2@1885.35,694.43
NetD18_1: D18.1 R87.2 | length 63.7
  Top Layer w8: D18.1@1961.68,694.43 R87.2@2025.35,694.43
NetD19_1: D19.1 R88.2 | length 68.7
  Top Layer w8: D19.1@2096.68,694.43 R88.2@2165.35,694.43
NetF1_2: F1.2 J8.2 TP2.1 | length 221.4
  Bottom Layer w50: TP2.1@3825.07,1884 3826.07,1883 4046.07,1883
  other v2: 4096.07,1729 4206.07,1729 4316.07,1729 4406.07,1729 4491.07,1729 4041.07,1799 4131.07,1804 4256.07,1804 4446.07,1809 4351.07,1814 4086.07,1879 4481.07,1879 4306.07,1884 4396.07,1884 4056.07,1974 4131.07,1974 4231.07,1974 4331.07,1974 4426.07,1974
NetJ4_1: J4.1 R1.1 | length 206.7
  Top Layer w20: R1.1@3471.07,1534.47 3471.07,1448 J4.1@3556.07,1363
NetJ6_2: J6.2 S1.1 S1.2 | length 518.9
  Top Layer w15: S1.2@1148.28,1865.26 1382.06,1865.26 ; J6.2@1288.07,1660.91 1288.07,1771.27 1382.06,1865.26 ; S1.1@1423.87,1865.26 1382.06,1865.26
NetJ7_1: J7.1 TP20.1 | length 171.9
  Top Layer w8: J7.1@2031.07,1184 2082.73,1184 TP20.1@2167.73,1099
NetJ7_3: J7.3 TP21.1 | length 152.4
  Top Layer w8: J7.3@2031.07,1284 2112.73,1284 TP21.1@2162.73,1234
NetJ7_6: J7.6 R94.2 | length 599.9
  Top Layer w8: R94.2@1461.07,1054 1477.66,1053.39 1477.81,1053.39 1481.1,1053.39 1836.76,1384 J7.6@1931.07,1384
NetJ7_8: J7.8 R95.2 | length 627.6
  Top Layer w8: R95.2@1461.07,1099 1486.53,1098.45 1486.61,1098.45 ; 1486.66,1098.44 1489.91,1098.44 1897.92,1489.21 1911.51,1489.21 J7.8@1931.07,1484
NetJ7_10: J7.10 R96.2 | length 662.7
  Top Layer w8: R96.2@1461.07,1139 1491.07,1139 1791.07,1439 1791.07,1461.18 1793.61,1463.71 J7.10@1931.07,1584
NetJ7_14: J7.14 R92.2 | length 886.8
  Top Layer w8: R92.2@1461.07,1189 1506.07,1189 1771.07,1454 1771.07,1749 1816.07,1784 J7.14@1931.07,1784
NetJ7_16: J7.16 R91.2 | length 946.2
  Top Layer w8: R91.2@1461.07,1234 1506.07,1234 1751.07,1479 1751.07,1839 ; 1751.39,1839 1811.07,1884 J7.16@1931.07,1884
NetJ7_18: J7.18 R93.2 | length 1013.6
  Top Layer w8: R93.2@1461.07,1274 1506.07,1274 1726.95,1494.87 1726.07,1929 1806.07,1984 J7.18@1931.07,1984
NetJ7_20: J7.20 R90.2 | length 1080
  Top Layer w8: R90.2@1461.07,1314 1511.07,1314 1706.07,1509 1706.07,2019 1806.07,2084 J7.20@1931.07,2084
NetJ9_2: J9.2 R63.1 | length 139.6
  Top Layer w15: R63.1@781.07,2896.56 782.06,2896.56 839.5,2954 J9.2@839.5,3011.4
NetJ9_4: J9.4 R62.1 | length 129.3
  Top Layer w15: R62.1@706.07,2896.56 707.06,2896.56 739.5,2929 J9.4@739.5,3011.4
NetJ10_5: J10.5 R66.2 | length 157.1
  Top Layer w10: R66.2@681.07,1901.28 681.07,1863.01 J10.5@765.07,1779.01
NetJ10_7: J10.7 R67.2 | length 146.7
  Top Layer w10: R67.2@606.07,1901.28 606.07,1838.01 J10.7@665.07,1779.01
NetJ11_1: J11.1 L1.1 | length 118.6
  Top Layer w10: J11.1@1226.63,3038.56 1224.51,2993.79 1278.52,2944.98 L1.1@1278.52,2944
NetJ11_5: J11.5 L2.1 | length 133.1
  Top Layer w10: L2.1@1058.63,2944 1067.76,2953.12 1105.2,2953.12 1126.71,2974.63 J11.5@1126.71,3027
NetR3_1: R3.1 U4.8
NetR4_2: R4.2 U4.1
NetR80_2: R80.2 S.1 | length 71.1
  Top Layer w8: R80.2@1361.07,316.56 S.1@1361.07,387.66