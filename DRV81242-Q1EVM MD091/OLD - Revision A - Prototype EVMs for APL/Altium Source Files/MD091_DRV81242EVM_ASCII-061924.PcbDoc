# Altium PCB MD091_DRV81242EVM_ASCII-061924.PcbDoc (part 3 of 5)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4586.07 x 3253 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 237 components, 133 nets, 665 pads, 296 vias.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
PolygonConnect PolygonConnect_91 [All vs IsNamedPolygon('TOP_LAYER_BOUT2_P242')] p4: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_90 [All vs IsNamedPolygon('TOP_LAYER_VM_P239')] p5: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_89 [All vs IsNamedPolygon('TOP_LAYER_BOUT1_P240')] p6: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_88 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P080')] p7: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_87 [All vs IsNamedPolygon('TOP_LAYER_VM_P125')] p8: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_86 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P080')] p9: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_85 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT2_P211')] p10: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_84 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P205')] p11: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_83 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P205')] p12: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_82 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P204')] p13: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_81 [All vs IsNamedPolygon('TOP_LAYER_NONET_P237')] p14: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_80 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p15: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_79 [All vs IsNamedPolygon('TOP_LAYER_VM_P229')] p16: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_78 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p17: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_77 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P221')] p18: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_76 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p19: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_75 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p20: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_74 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p21: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_73 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P221')] p22: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_72 [All vs IsNamedPolygon('TOP_LAYER_GND_P121')] p23: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_71 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173') Or  IsNamedPolygon('TOP_LAYER_OUT1_P129')] p24: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_70 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p25: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_69 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P129')] p26: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_68 [All vs IsNamedPolygon('TOP_LAYER_VM_P085')] p27: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_67 [All vs IsNamedPolygon('BOTTOM_LAYER_P_IN_P174')] p28: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_66 [All vs IsNamedPolygon('BOTTOM_LAYER_NETF1_2_P203')] p29: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_65 [All vs IsNamedPolygon('BOTTOM_LAYER_VBAT_P165')] p30: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_64 [All vs IsNamedPolygon('TOP_LAYER_VM_P167')] p31: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_63 [All vs IsNamedPolygon('TOP_LAYER_VM_P167')] p32: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_62 [All vs IsNamedPolygon('TOP_LAYER_VM_P171')] p33: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_61 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P199')] p34: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_60 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NETF1_2_P196')] p35: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_59 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VBAT_P197')] p36: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_58 [All vs IsNamedPolygon('SIGNAL_LAYER_2_P_IN_P198')] p37: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_57 [All vs IsNamedPolygon('SIGNAL_LAYER_2_3V3_P194')] p38: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_56 [All vs IsNamedPolygon('TOP_LAYER_NETF1_2_P207')] p39: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_55 [All vs IsNamedPolygon('TOP_LAYER_VBAT_P223')] p40: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_54 [All vs IsNamedPolygon('TOP_LAYER_P_IN_P227')] p41: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_53 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p42: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_52 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VM_P177') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P179') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P160') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P175') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P181')] p43: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_51 [All vs IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P136')] p44: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_50 [All vs IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P132')] p45: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_49 [All vs IsNamedPolygon('SIGNAL_LAYER_2_MCU_3V3_P192')] p46: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_48 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P190')] p47: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_47 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P184')] p48: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_46 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P241')] p49: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_45 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P241')] p50: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_44 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT2_P163')] p51: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_43 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P166')] p52: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_42 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P235')] p53: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_41 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P164')] p54: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_40 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P162')] p55: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_39 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VM_P160')] p56: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_38 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P138')] p57: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_37 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P146')] p58: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_36 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P156')] p59: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_35 [All vs IsNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P219')] p60: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_34 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P144')] p61: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_33 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P148') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P148')] p62: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_32 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P154')] p63: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_31 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P138')] p64: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_30 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P082')] p65: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_29 [All vs IsNamedPolygon('TOP_LAYER_GND_P076')] p66: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_28 [All vs IsNamedPolygon('TOP_LAYER_GND_P087')] p67: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_27 [All vs IsNamedPolygon('TOP_LAYER_VM_P127') Or  IsNamedPolygon('TOP_LAYER_VM_P085')] p68: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_26 [All vs IsNamedPolygon('TOP_LAYER_GND_P117')] p69: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_25 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P129') Or  IsNamedPolygon('TOP_LAYER_OUT2_P173')] p70: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_24 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P113')] p71: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_23 [All vs IsNamedPolygon('BOTTOM_LAYER_NONET_P115')] p72: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_22 [All vs IsNamedPolygon('SIGNAL_LAYER_1_NONET_P111')] p73: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_21 [All vs IsNamedPolygon('TOP_LAYER_NONET_P083')] p74: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_20 [All vs IsNamedPolygon('TOP_LAYER_NONET_P105')] p75: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_19 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P107')] p76: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_18 [All vs IsNamedPolygon('TOP_LAYER_NONET_P101')] p77: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_17 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P103')] p78: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_16 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P000')] p79: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_15 [All vs IsNamedPolygon('TOP_LAYER_NONET_P093')] p80: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_14 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P099')] p81: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_13 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P000')] p82: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_12 [All vs IsNamedPolygon('BOTTOM_LAYER_NONET_P079') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P078') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P077') Or  IsNamedPolygon('TOP_LAYER_NONET_P083') Or  IsNamedPolygon('BOTTOM_LAYER_NONET_P072') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P070') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P059') Or  IsNamedPolygon('TOP_LAYER_OUT2_P058') Or  IsNamedPolygon('BOTTOM_LAYER_NONET_P056') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P054') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P052') Or  IsNamedPolygon('TOP_LAYER_OUT1_P050') Or  IsNamedPolygon('BOTTOM_LAYER_VM_P044') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P042') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P040') Or  IsNamedPolygon('TOP_LAYER_VM_P038') Or  IsNamedPolygon('BOTTOM_LAYER_VM_P036') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P018') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P016') Or  IsNamedPolygon('TOP_LAYER_VM_P002')] p83: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_11 [All vs IsNamedPolygon('TOP_LAYER_NONET_P089') Or  IsNamedPolygon('TOP_LAYER_NONET_P090')] p84: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_10 [All vs IsNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P002') Or  IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201') Or  IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P018') Or  IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P016')] p85: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_9 [All vs IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123')] p86: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_8 [All vs IsNamedPolygon('TOP_LAYER_NONET_P072')] p87: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_7 [All vs IsNamedPolygon('TOP_LAYER_NONET_P072')] p88: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_6 [All vs IsNamedPolygon('TOP_LAYER_VM_P042')] p89: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_5 [All vs IsNamedPolygon('TOP_LAYER_VM_P044')] p90: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_4 [All vs IsNamedPolygon('TOP_LAYER_VM_P046')] p91: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_3 [All vs IsNamedPolygon('TOP_LAYER_GND_P036') Or  IsNamedPolygon('TOP_LAYER_OUT2_P040') Or  IsNamedPolygon('TOP_LAYER_OUT1_P038')] p92: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_2 [InNet('EZFET_VBUS') vs IsNamedPolygon('TOP_LAYER_EZFET_VBUS_P008')] p93: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_1 [InNetClass('Power-Net') vs IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201')] p94: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect [All] p95: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
RoutingCorners [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 cornerstyle=45-Degree minsetback=100 maxsetback=100
RoutingLayers [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 top layer=Automatic mid layer 1=Automatic mid layer 2=Automatic bottom layer=Automatic
RoutingPriority [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
RoutingTopology [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 topology=Shortest
RoutingVias [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
RoutingVias ThermalPadVias [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=63 holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62 // Protel DXP Scope 1 Expression Was: IsVia and InAnyComponent
RoutingVias ThermalPadVias [IsVia and InAnyComponent] p1: holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62
RoutingVias [All] p2: holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
ShortCircuit [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 allowed=FALSE
SilkToBoardRegionClearance [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=130 // Protel DXP Scope 1 Expression Was: Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)
SilkToBoardRegionClearance [Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)] p1:
SilkToSilkClearance [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=120 // Protel DXP Scope 2 Expression Was: (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [(HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small')) vs (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))] p1: silktosilkclearance=0
SilkToSilkClearance [All] p2: silktosilkclearance=3.94
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
SilkToSolderMaskClearance SilkToComponentPadClearance [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=87 // Protel DXP Scope 1 Expression Was: (IsPad or IsFill or IsRegion) and InAnycomponent
SilkToSolderMaskClearance SilkToComponentPadClearance [(IsPad or IsFill or IsRegion) and InAnycomponent] p1: minsilkscreentomaskgap=5 clearancetoexposedcopper=TRUE
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p2: minsilkscreentomaskgap=3.94 clearancetoexposedcopper=FALSE
SolderMaskExpansion [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 expansion=1.97
SolderMaskExpansion [All] p1: expansion=1.97 istentingtop=FALSE
UnRoutedNet [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
UnRoutedNet [All] p1: checkbadconnections=TRUE
UnpouredPolygon [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
Width [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 maxlimit=65 minlimit=6 preferedwidth=8
Width [All] p1: maxlimit=65 minlimit=6 preferedwidth=8 minimp=50.000000 maximp=50.000000 favimp=50.000000 checkconnectedcopper=TRUE
13 further rules are at their usual default settings.

## Classes and differential pairs
component class MD091E1_DRV81xxx: C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C16 C17 C18 C19 C55 C56 C57 D20 F1 J1 J3 J4 J5 J8 J12 J13 J14 J15 J16 J17 J18 J19 J21 J23 L3 R1 R3 R4 R97 R98 TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 TP37 TP38 TP39 TP40 TP41 U4 U5 VM VM_HS
component class MD091E1_Hardware: FID1 FID2 FID3 LBL1 LBL2 Logo1 Logo2 Logo4 Logo5 LOGO6
component class Logo: Logo2
component class Label: LBL1 LBL2
component class FiducialMark: FID1 FID2 FID3
component class MD091E1_MCU: C15 C41 C44 C45 C46 C49 C50 C51 C52 C53 C54 C59 D5 D6 D8 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 J6 J7 R9 R18 R19 R30 R31 R32 R37 R39 R40 R41 R43 R45 R47 R48 R49 R51 R52 R53 R54 R80 R81 R82 R83 R84 R85 R86 R87 R88 R90 R91 R92 R93 R94 R95 R96 S S1 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J36 TP19 TP20 TP21 TP22 TP23 TP24 TP25 TP26 TP27 TP28 TP29 TP30 TP31 TP32 TP33 TP34 TP35 TP36 U1 Y2
component class Shunt: SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J27 SH-J28 SH-J31 SH-J32 SH-J33 SH-J35 SH-J36
net class Power-Net: EZFET_VBUS EZFET_VCC GND MCU_3V3
component class Header: J2 J4 J6 J7 J9 J10 J15 J17 J18 J21 J23
component class MD091E1_ezFET: C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C42 C43 C47 C48 D1 D2 J2 J9 J10 J11 L1 L2 R55 R56 R57 R58 R59 R60 R61 R62 R63 R64 R65 R66 R67 R68 R72 R75 R76 R77 R78 SH-J27 SH-J28 SH-J31 SH-J32 SH-J33 SH-J35 U2 U3 U6 Y1
differential pair USB_D: +USB_D_P -USB_D_N
differential pair " ": +EZFET_D_P -EZFET_D_N

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
C1 "885012206114" 0603 2184.07,217.01 r90 top
C2 "885012206114" 0603 2744.07,217.01 r90 top
C3 "UMK107AB7105KA-T" FP-0603-L_1_6_0_15-W_0_8-IPC_C 4069.1,2155.82 r270 top
C4 "UMK107AB7105KA-T" FP-0603-L_1_6_0_15-W_0_8-IPC_C 3375.07,1097.62 r270 top
C5 "885012206095" FP-885012206095-MFG 4146.07,2155.22 r270 top
C6 "885012206095" 0603 2984.07,2288 r270 top
C7 "885012107011" 0805_150 2595.07,2278 r270 top
C8 "CC0603KPX7R9BB103" FP-CC0603-DA-MFG 3533.07,1091.62 r90 top
C9 "885012205018" FP-885012205018_0402-MFG 3491.07,1663.68 r90 top
C10 "885012206095" FP-885012206095-MFG 3454.07,1093.62 r270 top
C11 "CC0603KPX7R9BB103" FP-CC0603-DA-MFG 4226.07,2155.22 r90 top
C12 "1nF" FP-C0603C-CF-MFG 4306.07,2155.22 r270 top
C13 "EEE-FK1H151P" SM_RADIAL_G 4192.3,2439.14 r0 top
C14 "EEE-FK1H151P" SM_RADIAL_G 3916.07,1219 r0 top
C15 "885012206095" 0603 256.07,1369 r180 top
C16 "1nF" FP-C0603C-CF-MFG 3613.07,1096.62 r270 top
C17 "ZRB18AR61E106ME01L" FP-ZRB18AR61E106ME01L_0603-MFG 3366.59,1468 r0 top
C18 "12061C683KAT2A" 1206 3437.07,1307.08 r90 top
C19 "885012206114" 0603 4393.58,937 r180 top
C20 "885012106012" FP-885012106012_0603-MFG 1301.55,2744 r0 top
C21 "885012206095" 0603 1306.07,2819 r180 top
C22 "885012005058" FP-885012005058_0402-MFG 481.07,2719 r180 top
C23 "885012006085" FP-885012006085_0603-MFG 481.07,2869 r180 top
C24 "885012005058" FP-885012005058_0402-MFG 481.07,2769 r180 top
C25 "885012206095" 0603 231.07,2294 r180 top
C26 "885012005055" 0402 906.07,1944 r270 top
C27 "885012005055" 0402 831.07,1944 r270 top
C28 "885012206048" 0603L 706.07,2594 r90 top
C29 "885012206050" FP-885012206050_0603-MFG 231.07,2144 r0 top
C30 "885012206048" 0603L 781.07,2594 r90 top
C31 "875105240001" FP-875105240001_SMT_CAP_4MM3_4MM3-MFG 956.07,2244 r180 top
C32 "885012206095" 0603 231.07,2219 r180 top
C33 "885012206095" 0603 781.07,2744 r270 top
C34 "885012206095" 0603 531.07,1944 r90 top
C35 "885012206052" 0603 631.07,2869 r90 top
C36 "885012206095" 0603 706.07,2744 r270 top
C37 "885012206040" 0603 1031.07,2889 r180 top
C38 "885012106018" 0603 856.07,2594 r90 top
C39 "885012206040" 0603 1006.07,2594 r270 top
C40 "885012206052" 0603 931.07,2594 r90 top
C41 "885012006085" FP-885012006085_0603-MFG 1576.07,1739 r180 top
C42 "885012005055" 0402 1106.07,2594 r90 top
C43 "885012005055" 0402 1256.07,2594 r90 top
C44 "885012005055" 0402 271.07,944 r180 top
C45 "885012005055" 0402 256.07,1094 r180 top
C46 "885012206095" 0603 303.1,552.23 r0 top
C47 "885012206048" 0603L 1481.07,3019 r0 top
C48 "885012206095" 0603 856.07,2869 r270 top
C49 "885012206050" FP-885012206050_0603-MFG 491.02,629.9 r0 top
C50 "885012206095" 0603 256.07,1169 r180 top
C51 "875105240001" FP-875105240001_SMT_CAP_4MM3_4MM3-MFG 213.05,814.4 r0 top
C52 "885012206095" 0603 303.1,613.31 r180 top
C53 "885012206095" 0603 303.1,674.92 r180 top
C54 "885012206095" 0603 636.07,1449 r270 top
C55 "885012206114" 0603 3284.07,3036.39 r270 top
C56 "885012206114" 0603 2708.07,3038.59 r270 top
C57 "885012206114" 0603 4393.1,400.06 r180 top
C59 "885012006085" FP-885012006085_0603-MFG 1491.07,2539 r270 top
D1 "150060SS75000" WL-SMCW_RED 281.07,2494 r270 top
D2 "150060VS75000" WL-SMCW_GREEN 181.07,2494 r270 top
D5 "150080VS75000" 0805_A 402.87,429.47 r90 top
D6 "150080VS75000" 0805_A 3406.07,2337.66 r90 top
D8 "150080VS75000" 0805_A 720.33,428 r90 top
D10 "150080VS75000" 0805_A 1038.12,427 r90 top
D11 "150080VS75000" 0805_A 1197.01,427 r90 top
D12 "150080VS75000" 0805_A 1686.08,842.09 r90 top
D13 "150080VS75000" 0805_A 1826.08,842.09 r90 top
D14 "150080VS75000" 0805_A 1961.08,842.09 r90 top
D15 "150080VS75000" 0805_A 2101.08,842.09 r90 top
D16 "150080VS75000" 0805_A 1686.07,653.09 r270 top
D17 "150080VS75000" 0805_A 1826.07,653.09 r270 top
D18 "150080VS75000" 0805_A 1961.07,653.09 r270 top
D19 "150080VS75000" 0805_A 2101.07,653.09 r270 top
D20 "MMSZ4682-E3-08" SOD-123 4506.07,2389 r90 top
F1 "0466003.NR" 1206 4406.07,2123 r270 top
FID1 "Fiducial" Fiducial10-20 101.07,89 r0 top
FID2 "Fiducial" Fiducial10-20 4491.07,214 r0 top
FID3 "Fiducial" Fiducial10-20 101.07,3174 r0 top
J1 "691101710002" 691101710002 2447.08,205.2 r0 top
J2 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 166.07,1699 r270 top
J3 "691101710002" 691101710002 3013.66,205.2 r0 top
J4 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3556.07,1313 r270 top
J5 "1888700" FP-1888700_HDR4-MFG 3802.08,3061 r180 top
J6 "61300311121" WURTH_61300311121 1288.07,1660.91 r180 top
J7 "PEC10DAAN" SULLINS_PEC10DAAN 1981.07,1634 r180 top
J8 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 4261.04,1747.19 r90 top
J9 "61301421121" Wurth_61301421121 539.5,3061.4 r270 top
J10 "61301421121" Wurth_61301421121 665.07,1729.01 r270 top
J11 "629105150921" FP-629105150921_CONN_PTH_USB_8MM0_5MM6-MFG 1175.45,3130.49 r180 top
J12 "691101710002" 691101710002 3013.66,3048.2 r180 top
J13 "691101710002" 691101710002 2447.07,3050.68 r180 top
J14 "691101710002" 691101710002 4404.91,1178.06 r90 top
J15 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3952.08,2766 r180 top
J16 "691101710002" 691101710002 4404.91,670.85 r90 top
J17 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3650.08,2762 r0 top
J18 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3631,895 r180 top
J19 "1888700" FP-1888700_HDR4-MFG 3752.08,218 r0 top
J21 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3801.08,484 r180 top
J23 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3550.07,484 r180 top
L1 "742792621" 0603L 1306.07,2944 r0 top
L2 "742792621" 0603L 1031.07,2944 r180 top
L3 "7443320100" WE-HCC_1210 3686.07,2299 r270 top
LBL1 "THT-14-423-10" Label_650x200 1779.33,276.24 r0 top
LBL2 "EVM Folder" Label_375x375 2821.07,1309 r0 top
Logo1 "CE Mark" CE_Mark_5mm 3132,1312 r180 bottom
Logo2 "Texas Instruments" TI_Stacked_Overlay_Small 2701.33,781.67 r0 top
Logo3 "FCC disclaimer" FCC_disclaimer 6019.07,4970 r90 top
Logo4 "WEEE logo" WEEE_Minimum 2732,1352 r180 bottom
Logo5 "CAUTION.  READ USER GUIDE BEFORE USE" IEC_Caution_Small 2826.07,1929 r0 top
LOGO6 "CAUTION HOT SURFACE" IEC_HotSurface_Small 2831.07,1659 r0 top
R1 "SG73S1JTTD101J" FP-SG73S1JTTD101J_0603-MFG 3471.07,1564 r90 top
R3 "Resistor" 0603L 2925.63,2380 r0 top
R4 "Resistor" 0603L 2655.52,2379 r0 top
R9 "560050310009" FP-560050310009_0402-MFG 256.07,1294 r180 top
R18 "CRCW040247K0JNED" 0402 731.07,1444 r270 top
R19 "CRCW040247K0JNED" 0402 1586.07,2534 r90 top
R30 "RC0603JR-0710KL" 0603L 1426.07,1425.69 r270 top
R31 "RC0603JR-0710KL" 0603L 1521.07,1531.44 r270 top
R32 "RC0603JR-0710KL" 0603L 1521.07,1431.44 r270 top
R37 "560050310009" FP-560050310009_0402-MFG 256.07,1244 r0 top
R39 "RC0603JR-0710KL" 0603L 1171.07,1529 r270 top
R40 "RC0603JR-0710KL" 0603L 1258.28,1526.56 r270 top
R41 "RC0603JR-0710KL" 0603L 1341.07,1529.74 r270 top
R43 "CRCW06034K99FKEAC" 0603L 3406.06,2197.3 r90 top
R45 "Resistor" 0603L 720.31,286.64 r90 top
R47 "Resistor" 0603L 1038.1,285.64 r90 top
R48 "Resistor" 0603L 1196.99,285.64 r90 top
R49 "Resistor" 0603L 402.53,289.12 r90 top
R51 "RC0603JR-0710KL" 0603L 1171.07,1429 r270 top
R52 "RC0603JR-0710KL" 0603L 1258.28,1424 r270 top
R53 "RC0603JR-0710KL" 0603L 1341.07,1427.19 r270 top
R54 "RC0603JR-0710KL" 0603L 1426.07,1528.25 r270 top
R55 "RC0402FR-07220KL" 0402 381.07,2719 r180 top
R56 "CRCW0402240KFKED" 0402 381.07,2769 r180 top
R57 "CRCW040247K0JNED" 0402 381.07,2869 r180 top
R58 "RC0603JR-07470RL" 0603 381.07,1944 r270 top
R59 "RC0603JR-07560RL" 0603 456.07,1944 r270 top
R60 "RC0402FR-07220KL" 0402 381.07,2669 r0 top
R61 "CRCW0402150KFKED" 0402 381.07,2819 r0 top
R62 "Resistor" 0603L 706.57,2869 r270 top
R63 "Resistor" 0603L 781.57,2869 r270 top
R64 "560050310009" FP-560050310009_0402-MFG 981.07,1919 r270 top
R65 "560050310009" FP-560050310009_0402-MFG 756.07,1919 r270 top
R66 "560050310009" FP-560050310009_0402-MFG 681.07,1919 r270 top
R67 "560050310009" FP-560050310009_0402-MFG 606.07,1919 r270 top
R68 "Resistor" 0603L 856.07,2744 r270 top
R72 "CRCW040227R0JNED" 0402L 1156.07,2594 r270 top
R75 "CRCW040227R0JNED" 0402L 1206.07,2594 r270 top
R76 "CRCW04021K40FKED" 0402L 856.07,2434 r270 top
R77 "CRCW04021M00JNED" 0402L 931.07,2434 r90 top
R78 "CRCW040233K0JNED" 0402S 1481.07,3069 r180 top
R80 "Resistor" 0603L 1361.07,289 r90 top
R81 "Resistor" 0603L 1756.68,773.09 r90 top
R82 "Resistor" 0603L 1901.68,773.09 r90 top
R83 "Resistor" 0603L 2036.68,773.09 r90 top
R84 "Resistor" 0603L 2171.68,773.09 r90 top
R85 "Resistor" 0603L 1756.68,668.09 r90 top
R86 "Resistor" 0603L 1901.68,668.09 r90 top
R87 "Resistor" 0603L 2036.68,668.09 r90 top
R88 "Resistor" 0603L 2171.68,668.09 r90 top
R90 "RC0402FR-07100RL" 0402S 1441.07,1314 r0 top
R91 "RC0402FR-07100RL" 0402S 1441.07,1234 r0 top
R92 "RC0402FR-07100RL" 0402S 1441.07,1189 r0 top
R93 "RC0402FR-07100RL" 0402S 1441.07,1274 r0 top
R94 "RC0402FR-07100RL" 0402S 1441.07,1054 r0 top
R95 "RC0402FR-07100RL" 0402S 1441.07,1099 r0 top
R96 "RC0402FR-07100RL" 0402S 1441.07,1139 r0 top
R97 "RG1608P-913-B-T5" 0603L 4506.07,2179 r180 top
R98 "RG1608P-103-B-T5" 0603L 4506.07,2249 r0 top
S "150080SS75000" FP-150080SS75000-MFG 1362.47,429 r90 top
S1 "430481025816" FP-430481025816_SMT_SW_6MM2_6MM2-MFG 1286.07,1944 r180 top
SH-J6 "60900213421" Wurth_60900213421 1981.07,2084 r180 top
SH-J7 "60900213421" Wurth_60900213421 1981.07,1999 r180 top
SH-J8 "60900213421" Wurth_60900213421 1981.07,1894 r0 top
SH-J9 "60900213421" Wurth_60900213421 1981.07,1794 r0 top
SH-J10 "60900213421" Wurth_60900213421 1981.07,1689 r180 top
SH-J11 "60900213421" Wurth_60900213421 1981.07,1584 r0 top
SH-J12 "60900213421" Wurth_60900213421 1981.07,1489 r0 top
SH-J19 "60900213421" Wurth_60900213421 1981.07,1384 r180 top
SH-J27 "60900213421" Wurth_60900213421 969.05,1727.62 r90 top
SH-J28 "60900213421" Wurth_60900213421 869.05,1727.62 r90 top
SH-J31 "60900213421" Wurth_60900213421 769.05,1727.62 r90 top
SH-J32 "60900213421" Wurth_60900213421 569.05,1727.62 r90 top
SH-J33 "60900213421" Wurth_60900213421 669.05,1727.62 r90 top
SH-J35 "60900213421" Wurth_60900213421 1336.07,1661 r0 top
SH-J36 "60900213421" Wurth_60900213421 1981.07,1289 r180 top
TP1 "5011" Keystone5011 1328.07,2303 r0 top
TP2 "5010" Keystone5010 3825.07,1884 r0 top
TP3 "5012" Keystone5012 3119.07,2741 r180 top
TP4 "5011" Keystone5011 2921.07,2741 r0 top
TP5 "5012" Keystone5012 2546.07,2744 r180 top
TP6 "5011" Keystone5011 2317.07,2744 r270 top
TP7 "5012" Keystone5012 2348.07,522 r180 top
TP8 "5011" Keystone5011 3113.07,522 r0 top
TP9 "5010" Keystone5010 4202.07,2766 r0 top
TP10 "5010" Keystone5010 3440.07,2758 r180 top
TP11 "5012" Keystone5012 2917.07,522 r0 top
TP12 "5010" Keystone5010 3851.07,643 r0 top
TP13 "5011" Keystone5011 2550.07,522 r0 top
TP14 "5010" Keystone5010 3600.08,643 r90 top
TP15 "5012" Keystone5012 4091.07,901 r0 top
TP16 "5012" Keystone5012 4091.07,515 r0 top
TP17 "5010" Keystone5010 3862.07,897 r270 top
TP18 "5010" Keystone5010 4091.07,724 r0 top
TP19 "TP_H0.45P0.75" TP_H045P075 806.07,474 r0 top
TP20 "5002" Keystone5002 2167.73,1099 r0 top
TP21 "5002" Keystone5002 2162.73,1234 r0 top
TP22 "5002" Keystone5002 2162.73,1364 r0 top
TP23 "5002" Keystone5002 2167.73,1499 r0 top
TP24 "5002" Keystone5002 2177.73,1644 r0 top
TP25 "5002" Keystone5002 2171.91,1783.86 r180 top
TP26 "5002" Keystone5002 2172.73,1914 r180 top
TP27 "5002" Keystone5002 2167.73,2044 r180 top
TP28 "5002" Keystone5002 2176.07,2174 r180 top
TP29 "TP_H0.45P0.75" TP_H045P075 176.51,188.81 r0 top
TP30 "TP_H0.45P0.75" TP_H045P075 176.51,353.06 r90 top
TP31 "TP_H0.45P0.75" TP_H045P075 176.51,270.94 r90 top
TP32 "TP_H0.45P0.75" TP_H045P075 176.51,599.44 r0 top
TP33 "TP_H0.45P0.75" TP_H045P075 176.51,517.31 r90 top
TP34 "TP_H0.45P0.75" TP_H045P075 176.51,435.19 r0 top
TP35 "5011" Keystone5011 181.07,1969 r0 top
TP36 "5003" Keystone5003 426.07,1504 r0 top
TP37 "Jumper_2p" Harwin_D3082-05 2720.07,1037 r180 top
TP38 "Jumper_2p" Harwin_D3082-05 2004.07,2348 r0 top
TP39 "Jumper_2p" Harwin_D3082-05 2544.07,1654 r270 top
TP40 "5010" Keystone5010 3144.07,2373 r90 top
TP41 "5010" Keystone5010 4347.07,3061 r0 top
U1 "MSP430F5338IPZ" PZT0100A_N 731.23,1011 r0 top locked
U2 "MSP430F5528IRGCT" RGC0064B 569.92,2285.65 r0 top
U3 "TPS73533DRBR" DRB0008A 1006.07,2769 r90 top
U4 "LM9036M-3.3/NOPB" D0008A_N 2790.36,2246.19 r0 top
U5 "DRV81242HTSSOP" PWP0024T-MFG 3276.07,1709 r270 top locked
U6 "TPD2E001DRYR" DRY0006A 1171.39,2920.81 r90 top
VM "5010" Keystone5010 3825.07,1654 r0 top
VM_HS "5010" Keystone5010 3410,895 r90 top
Y1 "CSTNR4M00GH5L000R0" MuRata_CSTNR 556.43,2580.69 r180 top
Y2 "MS3V-T1R 32.768KHZ +/-20PPM 12.5PF" XTAL_MS3V-T1R 246.62,1017.94 r180 top