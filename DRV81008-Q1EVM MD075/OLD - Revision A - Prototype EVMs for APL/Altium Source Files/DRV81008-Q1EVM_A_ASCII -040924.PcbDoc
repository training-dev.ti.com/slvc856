# Altium PCB DRV81008-Q1EVM_A_ASCII -040924.PcbDoc (part 3 of 5)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4582 x 3242 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 244 components, 130 nets, 661 pads, 289 vias.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
PolygonConnect PolygonConnect_91 [All vs IsNamedPolygon('TOP_LAYER_BOUT2_P242')] p4: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_90 [All vs IsNamedPolygon('TOP_LAYER_VM_P239')] p5: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_89 [All vs IsNamedPolygon('TOP_LAYER_BOUT1_P240')] p6: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_88 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P080')] p7: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_87 [All vs IsNamedPolygon('TOP_LAYER_VM_P125')] p8: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_86 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P080')] p9: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_85 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT2_P211')] p10: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_84 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P205')] p11: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_83 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P205')] p12: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_82 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P204')] p13: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_81 [All vs IsNamedPolygon('TOP_LAYER_NONET_P237')] p14: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_80 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p15: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_79 [All vs IsNamedPolygon('TOP_LAYER_VM_P229')] p16: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_78 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p17: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_77 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P221')] p18: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_76 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p19: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_75 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p20: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_74 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p21: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_73 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P221')] p22: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_72 [All vs IsNamedPolygon('TOP_LAYER_GND_P121')] p23: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_71 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173') Or  IsNamedPolygon('TOP_LAYER_OUT1_P129')] p24: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_70 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p25: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_69 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P129')] p26: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_68 [All vs IsNamedPolygon('TOP_LAYER_VM_P085')] p27: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_67 [All vs IsNamedPolygon('BOTTOM_LAYER_P_IN_P174')] p28: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_66 [All vs IsNamedPolygon('BOTTOM_LAYER_NETF1_2_P203')] p29: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_65 [All vs IsNamedPolygon('BOTTOM_LAYER_VBAT_P165')] p30: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_64 [All vs IsNamedPolygon('TOP_LAYER_VM_P167')] p31: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_63 [All vs IsNamedPolygon('TOP_LAYER_VM_P167')] p32: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_62 [All vs IsNamedPolygon('TOP_LAYER_VM_P171')] p33: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_61 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P199')] p34: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_60 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NETF1_2_P196')] p35: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_59 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VBAT_P197')] p36: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_58 [All vs IsNamedPolygon('SIGNAL_LAYER_2_P_IN_P198')] p37: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_57 [All vs IsNamedPolygon('SIGNAL_LAYER_2_3V3_P194')] p38: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_56 [All vs IsNamedPolygon('TOP_LAYER_NETF1_2_P207')] p39: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_55 [All vs IsNamedPolygon('TOP_LAYER_VBAT_P223')] p40: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_54 [All vs IsNamedPolygon('TOP_LAYER_P_IN_P227')] p41: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_53 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p42: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_52 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VM_P177') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P179') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P160') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P175') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P181')] p43: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_51 [All vs IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P136')] p44: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_50 [All vs IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P132')] p45: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_49 [All vs IsNamedPolygon('SIGNAL_LAYER_2_MCU_3V3_P192')] p46: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_48 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P190')] p47: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_47 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P184')] p48: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_46 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P241')] p49: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_45 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P241')] p50: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_44 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT2_P163')] p51: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_43 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P166')] p52: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_42 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P235')] p53: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_41 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P164')] p54: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_40 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P162')] p55: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_39 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VM_P160')] p56: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_38 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P138')] p57: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_37 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P146')] p58: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_36 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P156')] p59: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_35 [All vs IsNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P219')] p60: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_34 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P144')] p61: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_33 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P148') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P148')] p62: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_32 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P154')] p63: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_31 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P138')] p64: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_30 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P082')] p65: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_29 [All vs IsNamedPolygon('TOP_LAYER_GND_P076')] p66: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_28 [All vs IsNamedPolygon('TOP_LAYER_GND_P087')] p67: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_27 [All vs IsNamedPolygon('TOP_LAYER_VM_P127') Or  IsNamedPolygon('TOP_LAYER_VM_P085')] p68: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_26 [All vs IsNamedPolygon('TOP_LAYER_GND_P117')] p69: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_25 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P129') Or  IsNamedPolygon('TOP_LAYER_OUT2_P173')] p70: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_24 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P113')] p71: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_23 [All vs IsNamedPolygon('BOTTOM_LAYER_NONET_P115')] p72: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_22 [All vs IsNamedPolygon('SIGNAL_LAYER_1_NONET_P111')] p73: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_21 [All vs IsNamedPolygon('TOP_LAYER_NONET_P083')] p74: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_20 [All vs IsNamedPolygon('TOP_LAYER_NONET_P105')] p75: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_19 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P107')] p76: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_18 [All vs IsNamedPolygon('TOP_LAYER_NONET_P101')] p77: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_17 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P103')] p78: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_16 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P000')] p79: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_15 [All vs IsNamedPolygon('TOP_LAYER_NONET_P093')] p80: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_14 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P099')] p81: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_13 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P000')] p82: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_12 [All vs IsNamedPolygon('BOTTOM_LAYER_NONET_P079') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P078') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P077') Or  IsNamedPolygon('TOP_LAYER_NONET_P083') Or  IsNamedPolygon('BOTTOM_LAYER_NONET_P072') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P070') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P059') Or  IsNamedPolygon('TOP_LAYER_OUT2_P058') Or  IsNamedPolygon('BOTTOM_LAYER_NONET_P056') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P054') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P052') Or  IsNamedPolygon('TOP_LAYER_OUT1_P050') Or  IsNamedPolygon('BOTTOM_LAYER_VM_P044') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P042') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P040') Or  IsNamedPolygon('TOP_LAYER_VM_P038') Or  IsNamedPolygon('BOTTOM_LAYER_VM_P036') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P018') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P016') Or  IsNamedPolygon('TOP_LAYER_VM_P002')] p83: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_11 [All vs IsNamedPolygon('TOP_LAYER_NONET_P089') Or  IsNamedPolygon('TOP_LAYER_NONET_P090')] p84: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_10 [All vs IsNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P002') Or  IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201') Or  IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P018') Or  IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P016')] p85: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_9 [All vs IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123')] p86: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_8 [All vs IsNamedPolygon('TOP_LAYER_NONET_P072')] p87: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_7 [All vs IsNamedPolygon('TOP_LAYER_NONET_P072')] p88: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_6 [All vs IsNamedPolygon('TOP_LAYER_VM_P042')] p89: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_5 [All vs IsNamedPolygon('TOP_LAYER_VM_P044')] p90: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_4 [All vs IsNamedPolygon('TOP_LAYER_VM_P046')] p91: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_3 [All vs IsNamedPolygon('TOP_LAYER_GND_P036') Or  IsNamedPolygon('TOP_LAYER_OUT2_P040') Or  IsNamedPolygon('TOP_LAYER_OUT1_P038')] p92: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_2 [InNet('EZFET_VBUS') vs IsNamedPolygon('TOP_LAYER_EZFET_VBUS_P008')] p93: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_1 [InNetClass('Power-Net') vs IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201')] p94: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect [All] p95: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
RoutingCorners [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 cornerstyle=45-Degree minsetback=100 maxsetback=100
RoutingLayers [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 top layer=Automatic mid layer 1=Automatic mid layer 2=Automatic bottom layer=Automatic
RoutingPriority [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
RoutingTopology [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 topology=Shortest
RoutingVias [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
RoutingVias ThermalPadVias [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=63 holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62 // Protel DXP Scope 1 Expression Was: IsVia and InAnyComponent
RoutingVias ThermalPadVias [IsVia and InAnyComponent] p1: holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62
RoutingVias [All] p2: holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
ShortCircuit [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 allowed=FALSE
SilkToBoardRegionClearance [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=130 // Protel DXP Scope 1 Expression Was: Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)
SilkToBoardRegionClearance [Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)] p1:
SilkToSilkClearance [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=120 // Protel DXP Scope 2 Expression Was: (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [(HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small')) vs (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))] p1: silktosilkclearance=0
SilkToSilkClearance [All] p2: silktosilkclearance=3.94
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
SilkToSolderMaskClearance SilkToComponentPadClearance [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=87 // Protel DXP Scope 1 Expression Was: (IsPad or IsFill or IsRegion) and InAnycomponent
SilkToSolderMaskClearance SilkToComponentPadClearance [(IsPad or IsFill or IsRegion) and InAnycomponent] p1: minsilkscreentomaskgap=5 clearancetoexposedcopper=TRUE
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p2: minsilkscreentomaskgap=3.94 clearancetoexposedcopper=FALSE
SolderMaskExpansion [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 expansion=1.97
SolderMaskExpansion [All] p1: expansion=1.97 istentingtop=FALSE
UnRoutedNet [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
UnRoutedNet [All] p1: checkbadconnections=TRUE
UnpouredPolygon [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
Width [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 maxlimit=65 minlimit=6 preferedwidth=8
Width [All] p1: maxlimit=65 minlimit=6 preferedwidth=8 minimp=50.000000 maximp=50.000000 favimp=50.000000 checkconnectedcopper=TRUE
13 further rules are at their usual default settings.

## Classes and differential pairs
component class MD075E1_DRV81xxx: C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C16 C55 C56 C57 C58 C60 C61 C62 C63 D20 F1 J1 J8 J12 J13 J14 J15 J16 J17 J18 J19 L3 R1 R3 R4 R97 R98 TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 TP37 TP38 TP39 TP40 TP41 U4 U5 VM
component class MD075E1_Hardware: FID1 FID2 FID3 LBL1 Logo1 Logo2 Logo3 Logo4 Logo5 LOGO6 ZZ1 ZZ2 ZZ3 ZZ4
component class Logo: Logo2
component class Label: LBL1
component class FiducialMark: FID1 FID2 FID3
component class AssemblyNote: ZZ1 ZZ2 ZZ3 ZZ4
component class MD075E1_MCU: C15 C41 C44 C45 C46 C49 C50 C51 C52 C53 C54 C59 D3 D5 D6 D8 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 J6 J7 R9 R18 R19 R30 R31 R32 R37 R39 R40 R41 R43 R45 R47 R48 R49 R51 R52 R53 R54 R80 R81 R82 R83 R84 R85 R86 R87 R88 R90 R91 R92 R93 R94 R95 R96 S1 SH-J1 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J36 TP19 TP20 TP21 TP22 TP23 TP24 TP25 TP26 TP27 TP28 TP29 TP30 TP31 TP32 TP33 TP34 TP35 TP36 U1 Y2
component class Shunt: SH-J1 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J31 SH-J32 SH-J33 SH-J34 SH-J35 SH-J36
net class Power-Net: EZFET_VBUS EZFET_VCC GND MCU_3V3
component class Header: J1 J2 J6 J7 J9 J10
component class MD075E1_ezFET: C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C42 C43 C47 C48 D1 D2 J2 J9 J10 J11 L1 L2 R55 R56 R57 R58 R59 R60 R61 R62 R63 R64 R65 R66 R67 R68 R72 R75 R76 R77 R78 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J31 SH-J32 SH-J33 SH-J34 SH-J35 U2 U3 U6 Y1
differential pair USB_D: +USB_D_P -USB_D_N
differential pair " ": +EZFET_D_P -EZFET_D_N

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
C1 "12061C683KAT2A" 1206 3889,2928 r0 top
C2 "ZRB18AR61E106ME01L" FP-ZRB18AR61E106ME01L_0603-MFG 3360.51,2890 r0 top
C3 "UMK107AB7105KA-T" FP-0603-L_1_6_0_15-W_0_8-IPC_C 4063.03,3586.82 r270 top
C4 "UMK107AB7105KA-T" FP-0603-L_1_6_0_15-W_0_8-IPC_C 3372,2591 r270 top
C5 "885012206095" FP-885012206095-MFG 4140,3586.22 r270 top
C6 "885012206095" 0603 2991,3863 r270 top
C7 "885012107011" 0805_150 2602,3853 r270 top
C8 "CC0603KPX7R9BB103" FP-CC0603-DA-MFG 3530,2585 r90 top
C9 "885012205018" FP-885012205018_0402-MFG 3485,3094.69 r90 top
C10 "885012206095" FP-885012206095-MFG 3451,2587 r270 top
C11 "CC0603KPX7R9BB103" FP-CC0603-DA-MFG 4220,3586.22 r90 top
C12 "1nF" FP-C0603C-CF-MFG 4300,3586.22 r270 top
C13 "EEE-FK1H151P" SM_RADIAL_G 4186.22,3870.14 r0 top
C14 "EEE-FK1H151P" SM_RADIAL_G 3910,2650 r0 top
C15 "885012206095" 0603 250,2800 r180 top
C16 "1nF" FP-C0603C-CF-MFG 3610,2590 r270 top
C20 "885012106012" FP-885012106012_0603-MFG 1295.47,4175 r0 top
C21 "885012206095" 0603 1300,4250 r180 top
C22 "885012005058" FP-885012005058_0402-MFG 475,4150 r180 top
C23 "885012006085" FP-885012006085_0603-MFG 475,4300 r180 top
C24 "885012005058" FP-885012005058_0402-MFG 475,4200 r180 top
C25 "885012206095" 0603 225,3725 r180 top
C26 "885012005055" 0402 900,3375 r270 top
C27 "885012005055" 0402 825,3375 r270 top
C28 "885012206048" 0603L 700,4025 r90 top
C29 "885012206050" FP-885012206050_0603-MFG 225,3575 r0 top
C30 "885012206048" 0603L 775,4025 r90 top
C31 "875105240001" FP-875105240001_SMT_CAP_4MM3_4MM3-MFG 950,3675 r180 top
C32 "885012206095" 0603 225,3650 r180 top
C33 "885012206095" 0603 775,4175 r270 top
C34 "885012206095" 0603 525,3375 r90 top
C35 "885012206052" 0603 625,4300 r90 top
C36 "885012206095" 0603 700,4175 r270 top
C37 "885012206040" 0603 1025,4320 r180 top
C38 "885012106018" 0603 850,4025 r90 top
C39 "885012206040" 0603 1000,4025 r270 top
C40 "885012206052" 0603 925,4025 r90 top
C41 "885012006085" FP-885012006085_0603-MFG 1570,3170 r180 top
C42 "885012005055" 0402 1100,4025 r90 top
C43 "885012005055" 0402 1250,4025 r90 top
C44 "885012005055" 0402 265,2375 r180 top
C45 "885012005055" 0402 250,2525 r180 top
C46 "885012206095" 0603 297.02,1983.23 r0 top
C47 "885012206048" 0603L 1475,4450 r0 top
C48 "885012206095" 0603 850,4300 r270 top
C49 "885012206050" FP-885012206050_0603-MFG 484.94,2060.9 r0 top
C50 "885012206095" 0603 250,2600 r180 top
C51 "875105240001" FP-875105240001_SMT_CAP_4MM3_4MM3-MFG 206.98,2245.41 r0 top
C52 "885012206095" 0603 297.02,2044.31 r180 top
C53 "885012206095" 0603 297.02,2105.92 r180 top
C54 "885012206095" 0603 630,2880 r270 top
C55 "885012206114" 0603 4450,4435 r270 top
C56 "885012206114" 0603 3900,1680 r90 top
C57 "885012206114" 0603 3875,4435 r270 top
C58 "885012206114" 0603 3328.33,1680 r90 top
C59 "885012006085" FP-885012006085_0603-MFG 1485,3970 r270 top
C60 "885012206114" 0603 3320,4435 r270 top
C61 "885012206114" 0603 2756.67,1680 r90 top
C62 "885012206114" 0603 2745,4435 r270 top
C63 "885012206114" 0603 2185,1680 r90 top
D1 "150060SS75000" WL-SMCW_RED 275,3925 r270 top
D2 "150060VS75000" WL-SMCW_GREEN 175,3925 r270 top
D3 "150080SS75000" FP-150080SS75000-MFG 1356.39,1860 r90 top (schematic designator S)
D5 "150080VS75000" 0805_A 396.79,1860.48 r90 top
D6 "150080VS75000" 0805_A 3400,3768.66 r90 top
D8 "150080VS75000" 0805_A 714.26,1859 r90 top
D10 "150080VS75000" 0805_A 1032.04,1858 r90 top
D11 "150080VS75000" 0805_A 1190.94,1858 r90 top
D12 "150080VS75000" 0805_A 1680,2273.09 r90 top
D13 "150080VS75000" 0805_A 1820,2273.09 r90 top
D14 "150080VS75000" 0805_A 1955,2273.09 r90 top
D15 "150080VS75000" 0805_A 2095,2273.09 r90 top
D16 "150080VS75000" 0805_A 1680,2084.09 r270 top
D17 "150080VS75000" 0805_A 1820,2084.09 r270 top
D18 "150080VS75000" 0805_A 1955,2084.09 r270 top
D19 "150080VS75000" 0805_A 2095,2084.09 r270 top
D20 "MMSZ4682-E3-08" SOD-123 4500,3820 r90 top
F1 "0466003.NR" 1206 4400,3554 r270 top
FID1 "Fiducial" Fiducial10-20 95,1520 r0 top
FID2 "Fiducial" Fiducial10-20 4485,1645 r0 top
FID3 "Fiducial" Fiducial10-20 95,4605 r0 top
J1 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 3470,2805 r270 top
J2 "HTSW-102-07-G-S" Samtec_HTSW-102-07-G-S 160,3130 r270 top
J6 "61300311121" WURTH_61300311121 1282,3091.91 r180 top
J7 "PEC10DAAN" SULLINS_PEC10DAAN 1975,3065 r180 top
J8 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 4254.96,3178.19 r90 top
J9 "61301421121" WURTH_61301421121 533.43,4492.4 r270 top
J10 "61301421121" WURTH_61301421121 659,3160.02 r270 top
J11 "629105150921" FP-629105150921_CONN_PTH_USB_8MM0_5MM6-MFG 1169.38,4561.5 r180 top
J12 "691101710002" 691101710002 4181.79,4446.8 r180 top
J13 "691101710002" 691101710002 4181.79,1665 r0 top
J14 "691101710002" 691101710002 3611.79,4446.8 r180 top
J15 "691101710002" 691101710002 3611.79,1665 r0 top
J16 "691101710002" 691101710002 3041.79,4446.8 r180 top
J17 "691101710002" 691101710002 3041.58,1664.69 r0 top
J18 "691101710002" 691101710002 2471.79,4446.8 r180 top
J19 "691101710002" 691101710002 2471.79,1665 r0 top
L1 "742792621" 0603L 1300,4375 r0 top
L2 "742792621" 0603L 1025,4375 r180 top
L3 "7443320100" WE-HCC_1210 3680,3730 r270 top
LBL1 "THT-14-423-10" Label_650x200 3850,2218 r0 top
Logo1 "CE Mark" CE_Mark_5mm 3360,2510 r180 bottom
Logo2 "Texas Instruments" TI_Stacked_Overlay_Small 2080,3913 r0 top
Logo3 "FCC disclaimer" FCC_disclaimer 6013,6401 r90 top
Logo4 "WEEE logo" WEEE_Minimum 2925,2495 r180 bottom
Logo5 "CAUTION.  READ USER GUIDE BEFORE USE" IEC_Caution_Small 2820,3360 r0 top
LOGO6 "CAUTION HOT SURFACE" IEC_HotSurface_Small 2825,3090 r0 top
R1 "SG73S1JTTD101J" FP-SG73S1JTTD101J_0603-MFG 3465,2995 r90 top
R3 "Resistor" 0603L 2950,3954 r0 top
R4 "Resistor" 0603L 2650,3954 r0 top
R9 "560050310009" FP-560050310009_0402-MFG 250,2725 r180 top
R18 "CRCW040247K0JNED" 0402 725,2875 r270 top
R19 "CRCW040247K0JNED" 0402 1580,3965 r90 top
R30 "RC0603JR-0710KL" 0603L 1420,2856.69 r270 top
R31 "RC0603JR-0710KL" 0603L 1515,2962.44 r270 top
R32 "RC0603JR-0710KL" 0603L 1515,2862.44 r270 top
R37 "560050310009" FP-560050310009_0402-MFG 250,2675 r0 top
R39 "RC0603JR-0710KL" 0603L 1165,2960 r270 top
R40 "RC0603JR-0710KL" 0603L 1252.2,2957.56 r270 top
R41 "RC0603JR-0710KL" 0603L 1335,2960.75 r270 top
R43 "CRCW06034K99FKEAC" 0603L 3399.98,3628.31 r90 top
R45 "Resistor" 0603L 714.24,1717.65 r90 top
R47 "Resistor" 0603L 1032.03,1716.65 r90 top
R48 "Resistor" 0603L 1190.92,1716.65 r90 top
R49 "Resistor" 0603L 396.45,1720.12 r90 top
R51 "RC0603JR-0710KL" 0603L 1165,2860 r270 top
R52 "RC0603JR-0710KL" 0603L 1252.2,2855 r270 top
R53 "RC0603JR-0710KL" 0603L 1335,2858.19 r270 top
R54 "RC0603JR-0710KL" 0603L 1420,2959.25 r270 top
R55 "RC0402FR-07220KL" 0402 375,4150 r180 top
R56 "CRCW0402240KFKED" 0402 375,4200 r180 top
R57 "CRCW040247K0JNED" 0402 375,4300 r180 top
R58 "RC0603JR-07470RL" 0603 375,3375 r270 top
R59 "RC0603JR-07560RL" 0603 450,3375 r270 top
R60 "RC0402FR-07220KL" 0402 375,4100 r0 top
R61 "CRCW0402150KFKED" 0402 375,4250 r0 top
R62 "Resistor" 0603L 700,4300 r270 top
R63 "Resistor" 0603L 775,4300 r270 top
R64 "560050310009" FP-560050310009_0402-MFG 975,3350 r270 top
R65 "560050310009" FP-560050310009_0402-MFG 750,3350 r270 top
R66 "560050310009" FP-560050310009_0402-MFG 675,3350 r270 top
R67 "560050310009" FP-560050310009_0402-MFG 600,3350 r270 top
R68 "Resistor" 0603L 850,4175 r270 top
R72 "CRCW040227R0JNED" 0402L 1150,4025 r270 top
R75 "CRCW040227R0JNED" 0402L 1200,4025 r270 top
R76 "CRCW04021K40FKED" 0402L 850,3865 r270 top
R77 "CRCW04021M00JNED" 0402L 925,3865 r90 top
R78 "CRCW040233K0JNED" 0402S 1475,4500 r180 top
R80 "Resistor" 0603L 1355,1720 r90 top
R81 "Resistor" 0603L 1750.61,2204.09 r90 top
R82 "Resistor" 0603L 1895.61,2204.09 r90 top
R83 "Resistor" 0603L 2030.61,2204.09 r90 top
R84 "Resistor" 0603L 2165.61,2204.09 r90 top
R85 "Resistor" 0603L 1750.61,2099.09 r90 top
R86 "Resistor" 0603L 1895.61,2099.09 r90 top
R87 "Resistor" 0603L 2030.61,2099.09 r90 top
R88 "Resistor" 0603L 2165.61,2099.09 r90 top
R90 "RC0402FR-07100RL" 0402S 1435,2745 r0 top
R91 "RC0402FR-07100RL" 0402S 1435,2665 r0 top
R92 "RC0402FR-07100RL" 0402S 1435,2620 r0 top
R93 "RC0402FR-07100RL" 0402S 1435,2705 r0 top
R94 "RC0402FR-07100RL" 0402S 1435,2485 r0 top
R95 "RC0402FR-07100RL" 0402S 1435,2530 r0 top
R96 "RC0402FR-07100RL" 0402S 1435,2570 r0 top
R97 "RG1608P-913-B-T5" 0603L 4500,3610 r180 top
R98 "RG1608P-103-B-T5" 0603L 4500,3680 r0 top
S1 "430481025816" FP-430481025816_SMT_SW_6MM2_6MM2-MFG 1280,3375 r180 top
SH-J1 "60900213421" Wurth_60900213421 4353.42,6612.57 r90 top
SH-J6 "60900213421" Wurth_60900213421 1975,3515 r180 top
SH-J7 "60900213421" Wurth_60900213421 1975,3430 r180 top
SH-J8 "60900213421" Wurth_60900213421 1975,3325 r0 top
SH-J9 "60900213421" Wurth_60900213421 1975,3225 r0 top
SH-J10 "60900213421" Wurth_60900213421 1975,3120 r180 top
SH-J11 "60900213421" Wurth_60900213421 1975,3015 r0 top
SH-J12 "60900213421" Wurth_60900213421 1975,2920 r0 top
SH-J19 "60900213421" Wurth_60900213421 1975,2815 r180 top
SH-J22 "60900213421" Wurth_60900213421 2565.22,6612.57 r270 top
SH-J23 "60900213421" Wurth_60900213421 1969.16,6612.57 r270 top
SH-J24 "60900213421" Wurth_60900213421 1373.1,6612.57 r270 top
SH-J25 "60900213421" Wurth_60900213421 3161.29,6612.57 r270 top
SH-J26 "60900213421" Wurth_60900213421 777.03,6612.57 r270 top
SH-J27 "60900213421" Wurth_60900213421 962.97,3158.62 r90 top
SH-J28 "60900213421" Wurth_60900213421 862.97,3158.62 r90 top
SH-J29 "60900213421" Wurth_60900213421 3757.35,6612.57 r270 top
SH-J31 "60900213421" Wurth_60900213421 762.97,3158.62 r90 top
SH-J32 "60900213421" Wurth_60900213421 562.97,3158.62 r90 top
SH-J33 "60900213421" Wurth_60900213421 662.97,3158.62 r90 top
SH-J34 "60900213421" Wurth_60900213421 4949.48,6612.57 r270 top
SH-J35 "60900213421" Wurth_60900213421 1330,3092 r0 top
SH-J36 "60900213421" Wurth_60900213421 1975,2720 r180 top
TP1 "5011" Keystone5011 4400,2785 r270 top
TP2 "5010" Keystone5010 4480,4175 r270 top
TP3 "5012" Keystone5012#1 4280.22,4175 r0 top
TP4 "5010" Keystone5010 3513.37,4175 r180 top
TP5 "5012" Keystone5012#1 4080,1945 r0 top
TP6 "5010" Keystone5010 4083.37,4175 r180 top
TP7 "5012" Keystone5012#1 3710.22,4175 r0 top
TP8 "5010" Keystone5010 4280.2,1945 r180 top
TP9 "5012" Keystone5012#1 3513.35,1945 r180 top
TP10 "5010" Keystone5010 3715,1945 r0 top
TP11 "5012" Keystone5012#1 3140.22,4175 r0 top
TP12 "5010" Keystone5010 3140.2,1945 r180 top
TP13 "5012" Keystone5012#1 2943.35,1945 r0 top
TP14 "5010" Keystone5010 2373.37,4175 r0 top
TP15 "5012" Keystone5012#2 2570,4175 r0 top
TP16 "5010" Keystone5010 2570.2,1945 r180 top
TP17 "5012" Keystone5012#1 2373.35,1945 r180 top
TP18 "5010" Keystone5010 2943.37,4175 r0 top
TP19 "TP_H0.45P0.75" TP_H045P075 800,1905 r0 top
TP20 "5002" Keystone5002 2161.65,2530 r0 top
TP21 "5002" Keystone5002 2156.65,2665 r0 top
TP22 "5002" Keystone5002 2156.65,2795 r0 top
TP23 "5002" Keystone5002 2161.65,2930 r0 top
TP24 "5002" Keystone5002 2171.65,3075 r0 top
TP25 "5002" Keystone5002 2165.84,3214.86 r180 top
TP26 "5002" Keystone5002 2166.65,3345 r180 top
TP27 "5002" Keystone5002 2161.65,3475 r180 top
TP28 "5002" Keystone5002 2170,3605 r180 top
TP29 "TP_H0.45P0.75" TP_H045P075 170.44,1619.82 r0 top
TP30 "TP_H0.45P0.75" TP_H045P075 170.44,1784.07 r90 top
TP31 "TP_H0.45P0.75" TP_H045P075 170.44,1701.94 r90 top
TP32 "TP_H0.45P0.75" TP_H045P075 170.44,2030.44 r0 top
TP33 "TP_H0.45P0.75" TP_H045P075 170.44,1948.32 r90 top
TP34 "TP_H0.45P0.75" TP_H045P075 170.44,1866.19 r0 top
TP35 "5011" Keystone5011 175,3400 r0 top
TP36 "5003" Keystone5003 420,2935 r0 top
TP37 "Jumper_2p" Harwin_D3082-05 1937.56,1569.33 r180 top
TP38 "Jumper_2p" Harwin_D3082-05 1970.04,4556.67 r0 top
TP39 "Jumper_2p" Harwin_D3082-05 4445,2415 r270 top
TP40 "5010" Keystone5010 3900,4080 r0 top
TP41 "5010" Keystone5010 3822,3363 r0 top
U1 "MSP430F5338IPZ" PZT0100A_N 725.16,2442 r0 top locked
U2 "MSP430F5528IRGCT" RGC0064B 563.85,3716.66 r0 top
U3 "TPS73533DRBR" DRB0008A 1000,4200 r90 top
U4 "LM9036M-3.3/NOPB" D0008A_N 2797.28,3821.19 r0 top
U5 "DRV81008HTSSOP" PWP0024T-MFG 3270,3140 r270 top
U6 "TPD2E001DRYR" DRY0006A 1165.32,4351.81 r90 top
VM "5010" Keystone5010 3819,3085 r0 top
Y1 "CSTNR4M00GH5L000R0" MURATA_CSTNR 550.36,4011.69 r180 top
Y2 "MS3V-T1R 32.768KHZ +/-20PPM 12.5PF" XTAL_MS3V-T1R 240.55,2448.95 r180 top
ZZ1 "This Assembly Note is for PCB labels only" AssemblyNoteLabel 5103,1876 r90 top
ZZ2 "These assemblies are ESD sensitive, ESD precautions shall be observed." AssemblyNote 4953,4341 r90 top
ZZ3 "These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable." AssemblyNote 4808,2791 r90 top
ZZ4 "These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified." AssemblyNote 4658,3116 r90 top