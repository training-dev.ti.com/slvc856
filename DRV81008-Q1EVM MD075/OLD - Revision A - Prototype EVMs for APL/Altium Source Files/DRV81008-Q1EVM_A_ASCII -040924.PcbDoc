# Altium PCB DRV81008-Q1EVM_A_ASCII -040924.PcbDoc (part 5 of 5)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4582 x 3242 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 244 components, 130 nets, 661 pads, 289 vias.

## Via types
v1: diameter 24, hole 16, Top Layer to Bottom Layer, tented both sides, 179 vias
v2: diameter 24, hole 8, Top Layer to Bottom Layer, tented both sides, 61 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 21 vias
v4: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 16 vias
v5: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 11 vias
v6: diameter 20, hole 8, Top Layer to Bottom Layer, tented both sides, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NetTP33_1: TP33.1 U1.20 | length 493
  Top Layer w10: v1(350,2290) 353.79,2290 367.99,2304.2 U1.20@421.02,2304.2
  Bottom Layer w10: TP33.1@170.44,1948.32 201.87,1979.75 201.87,2018.21 201.87,2141.87 v1(350,2290)
NetTP34_1: TP34.1 U1.21 | length 551.7
  Top Layer w10: v1(360,2250) 360,2253.01 391.17,2284.17 420.68,2284.17 U1.21@421.02,2284.52
  Bottom Layer w10: TP34.1@170.44,1866.19 225,1920.75 225,2136 339,2250 v1(360,2250)
nSCS: J7.19 TP28.1 U5.1 | length 1701
  Top Layer w8: J7.19@2025,3515 2070,3515 2160,3605 v1(2360,3605) ; v1(3410,3315) 3410.37,3314.63 3410.37,3252.78 U5.1@3410.75,3252.4
  Signal Layer 2 w8: v1(2360,3605) 2380,3625 3235,3625 3410,3450 v1(3410,3315)
nSCS_MCU: R90.1 U1.67 | length 495.3
  Top Layer w8: U1.67@1029.29,2520.74 v5(1089.26,2520.74) ; v5(1391.44,2745) R90.1@1415,2745
  Bottom Layer w8: v5(1089.26,2520.74) 1089.26,2549.26 1285,2745 v5(1391.44,2745)
nSLEEP: J7.9 TP24.1 U5.21 | length 1576.3
  Top Layer w8: J7.9@2025,3015 2111.65,3015 TP24.1@2171.65,3075 v1(2370,3075) ; U5.21@3333.98,3027.6 3333.98,2966.04 v1(3350,2950.02)
  Signal Layer 2 w8: v1@2370.49,3074.51 2605,2840 3080,2840 3190.02,2950.02 v1(3350,2950.02)
nSLEEP_MCU: R96.1 U1.71 | length 397.9
  Top Layer w8: U1.71@1029.29,2599.48 1256.7,2599.48 1286.18,2570 R96.1@1415,2570
OUT0_LS: C55.1 J12.1 TP3.1 U5.6 | length 2359.3
  Top Layer w15: U5.6@3282.8,3252.4 3282.8,3322.2
  Top Layer w20: 3282.8,3322.2 3284.55,3806 3284.55,3964.55 3355,4035 3676,4035 3830,4189 3940,4189 4055,4074 4184,4074 4280.22,4170.22 TP3.1@4280.22,4175 J12.1@4280.22,4466.49 4280.22,4471.49 C55.1@4450,4471.5
OUT1_LS: C56.1 J13.1 TP5.1 U5.19 | length 2204.2
  Top Layer w8: J13.1@4080,1648.67 4080.17,1648.5 J13.1@4083.35,1645.31
  Top Layer w15: 3282.8,2967.2 U5.19@3282.8,3027.6
  Top Layer w20: 3282.8,2967.2 3282.8,2932.8 3260,2910 3260,2273.51 3378.51,2155 3870,2155 TP5.1@4080,1945 J13.1@4083.35,1645.31 ; C56.1@3900,1648.5 J13.1@4080.17,1648.5
OUT2_LS: C57.1 J14.1 TP7.1 U5.7 | length 1741.3
  Top Layer w8: J14.1@3710.22,4471.49 J14.1@3715,4466.71
  Top Layer w15: v6(3245,3315) 3257.2,3302.8 U5.7@3257.2,3254.17 U5.7@3257.2,3252.4
  Top Layer w20: v6(3245,3315) 3245,3979 3340,4074 3609.22,4074 TP7.1@3710.22,4175 3715,4466.41 J14.1@3715,4466.71 ; J14.1@3710.22,4471.49 C57.1@3875,4471.5
OUT3_LS: C58.1 J15.1 TP9.1 U5.18 | length 1724.2
  Top Layer w8: J15.1@3510.17,1648.5 J15.1@3513.35,1645.31
  Top Layer w15: 3257.2,2967.2 U5.18@3257.2,3027.6
  Top Layer w20: 3254.92,2967.2 3220,2932.28 3220,2238.35 TP9.1@3513.35,1945 J15.1@3513.35,1645.31 ; C58.1@3328.33,1648.5 J15.1@3510.17,1648.5 ; TP9.1@3524.18,1955.82 TP9.1@3538.07,1941.93
OUT4_LS: C60.1 J16.1 TP11.1 U5.9 | length 1437.6
  Top Layer w8: J16.1@3145,4475 J16.1@3159.78,4460.22
  Top Layer w15: U5.9@3206.02,3252.4 3206.02,3308.93
  Top Layer w20: J16.1@3140.22,4466.49 TP11.1@3140.22,4175 3140.22,4156.87 3160,4137.09 3160,3362.18 3160,3353.9 3166.05,3347.85 3206.02,3308.93 ; J16.1@3145,4475 C60.1@3320,4476.5
OUT5_LS: C61.1 J17.1 TP13.1 U5.16 | length 1679.4
  Top Layer w8: J17.1@2939.65,1648.5 J17.1@2943.15,1645 J17.1@2943.35,1645.2 ; 3205,2965 3206.02,2966.02
  Top Layer w15: 3206.02,2966.02 U5.16@3206.02,3025.83 U5.16@3206.02,3027.6
  Top Layer w20: C61.1@2756.67,1648.5 J17.1@2939.65,1648.5 ; J17.1@2943.35,1645.2 TP13.1@2943.35,1945 2943.35,1958.35 3180,2195 3180,2940 3205,2965
OUT6_LS: C62.1 J18.1 TP15.1 U5.12 | length 1828.6
  Top Layer w8: J18.1@2570.22,4466.49 J18.1@2575.78,4460.93
  Top Layer w15: U5.12@3129.25,3252.4 3129.25,3319.25
  Top Layer w20: TP15.1@2570,4175 J18.1@2570.22,4466.49 C62.1@2745,4466.5 ; TP15.1@2570.22,4175 2686.11,4059.11 3032.89,4059.11 3122.42,3969.58 3122.42,3863.06 3129.25,3319.25
OUT7_LS: C63.1 J19.1 TP17.1 U5.13 | length 2126.4
  Top Layer w8: J19.1@2370.17,1648.5 J19.1@2373.35,1645.31 ; 3129.25,2960.75 3130,2960
  Top Layer w15: 3129.25,2960.75 U5.13@3129.25,3027.6
  Top Layer w20: C63.1@2185,1648.5 J19.1@2370.17,1648.5 ; J19.1@2373.35,1645.31 TP17.1@2373.35,1945 2583.35,2155 2994.71,2155 3129.32,2289.61 3130,2960
PUSH: J6.3 U1.36 | length 1161.9
  Top Layer w8: U1.36@685.79,2137.87 v1@685.79,2190.68
  Top Layer w10: U1.36@685.62,2137.7 U1.36@685.79,2137.87
  Signal Layer 1 w8: v1(686.11,2191) 686.11,2267.11 1185,2766 1185,3088.91 J6.3@1182,3091.91
RST/SBWTDIO: C41.2 C59.2 J6.1 J10.4 R18.2 R19.1 U1.96 | length 2495.4
  Top Layer w8: v1(1460,3550) 1530.47,3620.47 1532.05,3940.47 ; C59.2@1485,3940.47 1579.09,3940.47 R19.1@1580,3941.38
  Top Layer w10: U1.96@567.68,2746.13 567.68,2858.89 575,2866.21 v1(575,2870) ; J6.1@1382,3091.91 1393.24,3103.15 1455.88,3103.15 1477.73,3125 1495.47,3125 C41.2@1540.47,3170
  Top Layer w15: v1(698.86,2869.1) 700.59,2867.38 712.94,2867.38 725,2855.31 R18.2@725,2851.38
  Signal Layer 1 w12: v1(698.86,2869.1) 698.86,2993.89 705.35,3000.38 705.35,3121.93 739.8,3156.37 812.65,3156.37 J10.4@859,3110.02 ; J6.1@1382,3091.91 1460,3169.91 v1(1460,3550)
  Signal Layer 2 w12: J10.4@859,3110.02 905.35,3156.37 1317.54,3156.37 1379.04,3094.87 J6.1@1379.04,3090
  Signal Layer 2 w15: v1(575,2870) 697.96,2870 v1(698.86,2869.1)
SCLK: J7.17 TP27.1 U5.2 | length 1690.4
  Top Layer w8: J7.17@2025,3415 2101.65,3415 TP27.1@2161.65,3475 ; TP27.1@2174.64,3487.98 TP27.1@2161.65,3475 ; v1(2360,3475) TP27.1@2161.65,3475 ; U5.2@3385.16,3252.4 v1(3385.16,3340.83)
  Signal Layer 2 w8: v1(2360,3475) 2475,3590 3220,3590 3382.9,3422.01 3385.16,3419.68 v1(3385.16,3340.83)
SCLK_MCU: R93.1 U1.62 | length 552.7
  Top Layer w8: U1.62@1029.29,2422.32 1030.02,2423.04 1083.22,2423.04 v5(1084.94,2424.77) ; v5(1391.44,2705) R93.1@1415,2705
  Bottom Layer w8: v5(1084.94,2424.77) 1120,2459.83 1120,2544.99 1280.01,2705 v5(1391.44,2705)
SDI: J7.15 TP26.1 U5.3 | length 1649.3
  Top Layer w8: J7.15@2025,3315 2136.65,3315 TP26.1@2166.65,3345 v1(2360,3345) ; U5.3@3359.57,3252.4 3359.78,3252.62 3359.78,3369.78 v1(3360,3370)
  Signal Layer 2 w8: v1(2360,3345) 2570,3555 3210,3555 3360,3405 v1(3360,3370)
SDI_MCU: R91.1 U1.65 | length 528.1
  Top Layer w8: U1.65@1029.29,2481.37 1072.42,2481.37 1097.63,2456.16 1152.78,2456.16 v5(1153.81,2457.19) ; v5(1391.44,2665) R91.1@1415,2665
  Bottom Layer w8: v5(1153.81,2457.19) 1153.81,2534.78 1284.02,2665 v5(1391.44,2665)
SDO: J7.13 TP25.1 U5.4 | length 1556
  Top Layer w8: J7.13@2025,3215 2165.7,3215 TP25.1@2165.84,3214.86 ; TP25.1@2165.9,3214.93 TP25.1@2165.84,3214.86 ; v1(2364.18,3214.86) TP25.1@2165.84,3214.86 ; U5.4@3333.6,3254.55 v1@3333.6,3316.4
  Signal Layer 2 w8: v1(2364.18,3214.86) 2639.32,3490 3160,3490 v1(3333.23,3316.77)
SDO_MCU: R92.1 U1.66 | length 446.6
  Top Layer w8: U1.66@1029.29,2501.06 1075.18,2501.06 1090.93,2485.31 1207.01,2485.31 v5(1208.87,2487.18) ; v5(1391.44,2620) R92.1@1415,2620
  Bottom Layer w8: v5(1208.87,2487.18) 1341.7,2620 v5@1390,2620
T_RST_RST: R65.1 U2.43 | length 477.8
  Top Layer w10: U2.43@737.07,3765.87 737.35,3765.6 757.4,3765.6 758,3765 v1(785,3765) ; R65.1@750,3367.72 751.97,3367.72 767.32,3383.07 767.32,3387.32 v1(770,3390)
  Signal Layer 1 w10: v1(770,3390) 805,3425 805,3745 v1(785,3765)
T_TEST_TCKC: R64.1 U2.44 | length 569.4
  Top Layer w10: U2.44@737.07,3785.56 770.38,3785.56 774.7,3789.87 811.34,3789.87 816.21,3785 v1(820,3785) ; v1(945,3415) 947.68,3412.32 947.68,3393.07 970.16,3370.59 972.13,3370.59 R64.1@975,3367.72
  Signal Layer 1 w10: v1(820,3785) 945,3660 v1(945,3415)
TST/SBWTCK: J10.2 U1.91 | length 706.3
  Top Layer w10: v1(644.17,2794.45) 647.29,2794.45 665.76,2775.99 665.76,2746.48 U1.91@666.1,2746.13
  Signal Layer 1 w10: v1(945,2830) 1015,2900 1015,3054.02 J10.2@959.5,3109.52
  Signal Layer 2 w10: v1(644.17,2794.45) 909.45,2794.45 v1(945,2830)
USB_D_N: J11.2 R72.1 U6.3 | length 479.9
  Top Layer w8: J11.2@1197.41,4471.39 1197.41,4418.95 1218.06,4398.3 1218.06,4368.43 1193.51,4343.87 1186.91,4343.87 1185,4341.97 1185,4308.38 1184.84,4308.22 1184.84,4290.16 v1(1200,4275)
  Top Layer w15: R72.1@1150,4044.69 v1(1150,4095)
  Signal Layer 1 w15: v1(1150,4095) 1200,4145 v1(1200,4275)
USB_D_P: J11.3 R75.1 U6.2 U6.5 U6.6 | length 462.8
  Top Layer w8: U6.6@1145.63,4363.62 U6.5@1165.31,4363.62 ; v1(1150,4275) 1165.16,4290.16 1165.16,4316.38 1165.31,4316.54 U6.5@1165.31,4363.62 ; J11.3@1171.82,4458.01 1171.82,4452.69 1166.16,4447.04 1166.16,4364.47 U6.5@1165.31,4363.62
  Top Layer w15: R75.1@1200,4044.69 v1(1200,4095)
  Signal Layer 2 w15: v1(1150,4275) 1150,4145 v1(1200,4095)
VBAT_MON: D20.1 R97.1 R98.2 U1.97 | length 5648.6
  Top Layer w8: U1.97@547.99,2746.13 547.99,2562.01 685.25,2424.75 815.25,2424.75 v1(935,2305)
  Top Layer w10: D20.1@4500,3755.53 4527.56,3727.97 R98.2@4527.56,3680 R97.1@4527.56,3610 4525,3607.44 v2(4525,3560)
  Signal Layer 2 w8: v1(935,2305) 1078,2305 1271,2112 3919,2112 4311,2504 4311,2858 4525,3072 v2(4525,3560)
VDD: C9.1 R1.2 U5.24 | length 57.6
  Top Layer w8: U5.24@3410.75,3027.6 3456.93,3027.6 R1.2@3465,3019.53
VDD_3V3: C7.1 J1.2 R4.1
  other v2: 2556,3886 2590,3943
VM: C1.1 C2.1 C4.1 C8.2 C10.1 C14.1 C16.1 J12.2 J13.2 J14.2 J15.2 J16.2 J17.2 J18.2 J19.2 L3.2 TP4.1 TP6.1 TP8.1 TP10.1 TP12.1 TP14.1 TP16.1 TP18.1 TP41.1 U5.20 VM.1 | length 8665.7
  Top Layer w8: J18.2@2373.37,4466.49 J18.2@2375,4464.86 ; TP18.1@2943.37,4185.22 TP18.1@2951.79,4176.8 ; TP4.1@3513.37,4180.22 TP4.1@3521.79,4171.8 ; J15.2@3710.2,1645.31 J15.2@3715,1650.11
  Top Layer w10: U5.20@3308.39,3025.83 3308.39,2981.61 v5(3310,2980)
  Top Layer w40: TP14.1@2373.37,4175 J18.2@2375,4464.86 ; J19.2@2570,1646.37 TP16.1@2570.2,1935 ; TP18.1@2943.37,4185.22 J16.2@2943.37,4466.49 ; J17.2@3140,1645 TP12.1@3140,1950.7 ; TP4.1@3513.37,4180.22 J14.2@3513.37,4466.49 J14.2@3513.37,4471.49 ; J15.2@3715,1650.11 TP10.1@3715,1945 ; TP6.1@4083.37,4175 J12.2@4083.37,4466.49 J12.2@4083.37,4471.49 ; J13.2@4280.2,1645.31 TP8.1@4280.2,1913.09
  Bottom Layer w40: TP14.1@2373.37,4175 2487.37,4061 2829.37,4061 TP18.1@2943.37,4175 3057.37,4061 3399.37,4061 TP4.1@3513.37,4175 3627.37,4061 3739,4061 3853,4175 TP6.1@4083.37,4175 4083.37,3831.37 3822,3570 TP41.1@3822,3363 ; TP16.1@2570.2,1945 2759.6,2152.63 2760.25,2153.28 2771.96,2165 3275,2165 ; TP12.1@3140.2,1945 3212.1,2016.89 3212.1,2102.1 3275,2165 ; TP10.1@3715,1945 3715,2037.72 3775,2097.72 3775,2165 ; VM.1@3819,3085 3819,2683 3775,2639 3775,2165 ; TP8.1@4280.2,1945 4060.2,2165 3775,2165 ; 3275,2165 3775,2165
  other v2: 3605,2936 3705,2936 3605,3036 3705,3036 3605,3136 3705,3136 3605,3236 3705,3236 3605,3336 3705,3336 3605,3436 3705,3436
  other v5: 3312.81,2858.19 3337.81,2858.19
VS: C3.1 C5.1 C6.1 C11.2 C12.1 C13.1 D6.2 F1.1 L3.1 R3.2 R97.2 TP40.1
  other v2: 3389,3858 3464,3858 3024,3895 3009,3951 3389,3958 3464,3958
pads on no net: FID1.1 FID2.1 FID3.1 J7.11 J7.12 J9.6 J9.10 J9.12 J9.13 J9.14 J10.11 J10.12 J11.4 LBL1.0 SH-J1.0 SH-J6.0 SH-J7.0 SH-J8.0 SH-J9.0 SH-J10.0 SH-J11.0 SH-J12.0 SH-J19.0 SH-J22.0 SH-J23.0 SH-J24.0 SH-J25.0 SH-J26.0 SH-J27.0 SH-J28.0 SH-J29.0 SH-J31.0 SH-J32.0 SH-J33.0 SH-J34.0 SH-J35.0 SH-J36.0 U1.1 U1.2 U1.3 U1.4 U1.5 U1.6 U1.7 U1.8 U1.17 U1.18 U1.23 U1.24 U1.28 U1.30 U1.31 U1.32 U1.33 U1.38 U1.39 U1.40 U1.41 U1.48 U1.49 U1.58 U1.59 U1.68 U1.72 U1.73 U1.74 U1.75 U1.77 U1.78 U1.79 U1.80 U1.81 U1.82 U1.84 U1.85 U1.86 U1.92 U1.93 U1.94 U1.95 U1.98 U1.99 U1.100 U2.3 U2.4 U2.5 U2.6 U2.7 U2.8 U2.10 U2.12 U2.13 U2.18 U2.19 U2.22 U2.23 U2.24 U2.25 U2.26 U2.27 U2.28 U2.29 U2.30 U2.31 U2.32 U2.33 U2.34 U2.35 U2.36 U2.41 U2.42 U2.45 U2.46 U2.47 U2.48 U3.2 U3.6 U3.7 U5.8 U5.10 U5.11 U5.14 U5.15

## Polygon pours and split planes (outlines as drawn)
GND on Bottom Layer "BOTTOM_LAYER_GND_P301" (solid, pour order 301): 17.16,1448.82 4586.16,1448.82 4586.16,4687.82 17.16,4687.82
VDD_3V3 on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 297): 2439,3914 2439,2741 2661,2519 3470,2519 3518,2567 3518,2756 3483,2791 2823,2791 2682,2932 2682,3921 2645,3958 2483,3958
VM on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 300): 3295,3046 3295,2848 3307,2836 3345,2836 3351,2842 3351,2913 3325,2939 3325,2961 3332,2968 3497,2968 3549,2916 3852,2916 3882,2946 3882,3451 3837,3496 3611,3496 3564,3449 3564,3094 3523,3053 3302,3053
VS on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 296): 2988,3886 3051,3823 3896,3823 3975,3902 3975,4096 3946,4125 3879,4125 3745,3991 3028,3991 2988,3951
NetF1_2 on Bottom Layer "BOTTOM_LAYER_NETF1_2_P284" (solid, remove dead copper, pour order 284): 4009,3140.57 4009,3428 4034,3453 4517,3453 4550,3421 4550,3140 4549.43,3140.57
GND on Top Layer "TOP_LAYER_GND_P298" (solid, pour order 298): 15.78,4675 4577,4675 4577,1438 8,1438
VM on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 291): 3300,3056 3299,3055 3299,2976 3303,2972 3303,2635 3342,2596 3810,2596 3866,2652 3866,2970 3959,3063 3959,3565 3905,3619 3602,3619 3553,3570 3553,2720 3531,2698 3412,2698 3348,2762 3348,2921 3317,2952 3317,3054 3315,3056 3314,3056
VS on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 295): 2960,3971 2960,3886 2974,3872 3020,3872 3038,3890 3038,3944 3006,3976 2965,3976
VDD_3V3 on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 294): 2555,3972 2543,3960 2543,3878 2558,3863 2630,3863 2639,3872 2639,3969 2636,3972
VS on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 292): 3364,3793 3364,3960 3419,4015 3727,4015 3837,4126 3924,4126 4109,3941 4109,3731 4178,3662 4482,3662 4497,3647 4497,3593 4491,3587 4038,3587 3841,3784 3373,3784
NetF1_2 on Top Layer "TOP_LAYER_NETF1_2_P288" (solid, remove dead copper, pour order 288): 4006.93,3466.93 4068.5,3528.5 4501.5,3528.5 4550,3480 4550,3140 4549.43,3140.57 4006.93,3140.57
GND on Signal Layer 1 "SIGNAL_LAYER_1_GND_P184" (solid, remove dead copper, pour order 184): 15.78,4675 4577,4675 4577,1438 8,1438
GND on Signal Layer 2 "SIGNAL_LAYER_2_GND_P275" (solid, pour order 275): 17.16,1448.82 4586.16,1448.82 4586.16,4687.82 17.16,4687.82

## Keep-outs
Keep-Out Layer:
  circle w10: c4744.09,255.91 r118.11
  circle w10: c255.91,255.91 r118.11
  text ".Layer_Name" at 577,-858.49 h50

## Other copper
Top Layer:
  text ".Layer_Name" at 577,-858.49 h50
Signal Layer 1:
  text "Signal Layer 1" at 416,-862.01 h60
Signal Layer 2:
  text "Signal Layer 2" at 481,-868.01 h60
Bottom Layer:
  text ".Layer_Name" at 577,-858.49 h50

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  circle w10: c377,2678 r2.24
  lines w5: 1190.94,1928 1190.94,1938 ; 1395.68,1851.84 1425.68,1851.84 1410.68,1851.84 ; 1410.68,1841.84 1410.68,1851.84 ; 1410.68,1881.84 1410.68,1866.84 1395.68,1866.84 ; 1414.67,1833.53 1427.21,1821 ; 1417.21,1821 1427.21,1821 ; 1427.21,1831 1427.21,1821 ; 1431.95,1845.26 1443.21,1834 ; 1433.21,1834 1443.21,1834 ; 1443.21,1844 1443.21,1834 ; 1395.68,1866.84 1410.68,1851.84 ; 1395.68,1866.84 1425.68,1866.84 1410.68,1851.84 ; 1395.68,1866.84 1410.68,1851.84 ; 3848,4529 3863,4544 3863,4514 3848,4529
  lines w10: 2214.09,2927.5 2368.75,2926.25 ; 2215.56,3475 2360,3475 ; 2218.34,3214.86 2354.3,3214.86 ; 2219.15,3345 2355.12,3345 ; 2221.84,2795 2386.18,2795 ; 2222.5,3605.12 2361.36,3606.36 ; 2224.15,3075 2367.06,3075 ; 1580.61,1929.09 1580.61,2437.03 2255.61,2437.03 2255.61,1929.09 1580.61,1929.09 ; 3102.41,2950 3597.56,2950 3597.56,3450.01 3102.41,3450.01 3102.41,2950
  text "For EZFET-LITE Flashing Only" at 198,4608 h25
  text "GND" at 1891.51,4452.66 h60
  text "OUT0" at 4199,4107 h35 r90
  text "VM" at 3983,4073 h35
  text "OUT6" at 2518,4048 h35
  text "OUT2" at 3648,4048 h35
  text "OUT4" at 3073,4046.96 h35
  text "VM" at 2916.03,4037.61 h35
  text "VM" at 3490.18,4037.61 h35
  text "VM" at 2341,4034 h35
  text "1" at 346,3875 h25
  text "nSCS" at 2259,3624 h40
  text "RST" at 1225,3524 h60
  text "SCLK" at 2254,3499 h40
  text "DRV81008-Q1" at 3123.76,3394.54 h33
  text "SDI" at 2259,3369 h40
  text "GND" at 100,3250 h60
  text "SDO" at 2259,3234 h40
  text "PUSH" at 1118.91,3162.9 h25
  text "RST" at 1374.76,3160.38 h25
  text "nSLEEP" at 2249,3099 h40
  text "GND" at 3894,3064 h40
  text "1" at 1415,3012 h25
  text "3" at 1155,3011 h25
  text "IN1" at 2259,2954 h40
  text "3V3" at 99.73,2922.14 h60
  text "IN0" at 2259,2814 h40
  text "GND" at 4199,2769 h40
  text "3V3" at 2249,2644 h40
  text "GND" at 2249,2509 h40
  text "CHANNEL STATUS" at 1617,2392 h35
  text "MD075A" at 3663,2340 h60
  text "GND" at 4370,2335 h60 r90
  text "DRV81008-Q1EVM_A" at 2606,2330 h50
  text "CH6" at 1656.61,2170.09 h20
  text "CH4" at 1798.42,2168.36 h20
  text "CH2" at 1932.79,2168.36 h20
  text "CH0" at 2073.42,2168.36 h20
  text "OUT7" at 2310.55,2053 h35
  text "OUT5" at 2863,2053 h35
  text "OUT3" at 3463,2053 h35
  text "OUT1" at 4033,2053 h35
  text "VM" at 2551,2044 h35
  text "VM" at 3111,2044 h35
  text "VM" at 3691,2044 h35
  text "VM" at 4261,2044 h35
  text "CH7" at 1656,1947 h20
  text "CH3" at 1933,1945 h20
  text "CH1" at 2069,1945 h20
  text "CH5" at 1796,1943 h20
  text "GND" at 1867.56,1626.33 h60
  text "MCU_3V3" at 315.34,1612 h40 r90
  text "GUI_STATUS" at 944.34,1602 h40 r90
  text "FAULT_STATUS" at 1290.34,1598 h40 r90
  text "DRV_STATUS" at 1121.34,1596 h40 r90
  text "MCU_STATUS" at 620.34,1587 h40 r90
  text ".Layer_Name" at 577,-858.49 h50
Bottom Overlay:
  drawing of 2342 lines, arcs and shapes, not listed
  text "305-PD-24-0389" at 2515.44,2121 h150
  text "APR 2024" at 2238,1966 h150
  text ".Layer_Name" at 577,-858.49 h50
Top Paste:
  text ".Layer_Name" at 577,-858.49 h50
Bottom Paste:
  text ".Layer_Name" at 577,-858.49 h50
Top Solder:
  text ".Layer_Name" at 577,-858.49 h50
  text ".Layer_Name" at 577,-858.49 h50
Bottom Solder:
  text ".Layer_Name" at 577,-858.49 h50
Drill Guide:
  text ".Layer_Name" at 577,-858.49 h50
M1 Board Outline:
  the board outline again, w10
  text ".Layer_Name" at 577,-858.49 h50
M2 Board Dimensions:
  rectangle: 0,-275 125,-150
  rectangle: 125,-400 500,-275
  lines w7: 0,-275 1000,-275 ; 125,-400 125,-150 ; 250,-400 250,-150 ; 500,-400 500,-150 ; 750,-400 750,-150 ; 0,-400 1000,-400 1000,-150 0,-150 0,-400
  text ".Layer_Name" at 577,-858.49 h50
M3 3D STEP Top:
  text ".Layer_Name" at 577,-858.49 h50
M4 3D STEP Bottom:
  text ".Layer_Name" at 577,-858.49 h50
M5 Assembly Top:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 1153.5,-318.5 h25
  text "ASSEMBLY VARIANT:" at 1153,-434 h25
  text ".VariantName" at 2189,-434 h25
  text "PCB VIEWED FROM TOP SIDE" at -228.5,-655.67 h25
  text "BOARD #:" at 2248,-655.67 h25
  text ".PRJ_Number" at 2793.5,-655.67 h25
  text "REV:" at 3638,-655.67 h25
  text ".PCB_Rev" at 3929.5,-655.67 h25
  text "SVN REV:" at 4476,-655.67 h25
  text ".VersionControl_RevNumber" at 4982,-655.67 h25
  text "TID #:" at 2248,-859 h25
  text ".TID" at 2793.5,-859 h25
  text "PLOT NAME =" at -228.5,-1064.34 h25
  text ".plot_File_Name" at 577,-1064.34 h25
  text "GENERATED    :" at 2250,-1064.34 h25
  text ".Print_Date" at 3119.5,-1064.34 h25
  text ".Print_Time" at 3848.5,-1064.34 h25
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h25
M6 Assembly Bottom:
  lines w10: -292.5,-727.33 6309.5,-727.33 ; -290.5,-930.67 6309.5,-930.67 ; 1115.5,-1140.5 1115.5,-937.67 ; 1737.5,-727.33 1737.5,-524 ; 2577.5,-727.33 2577.5,-524 ; 3844.5,-1134 3844.5,-524 ; 4733.5,-1134 6309,-1134 6309,-524 -292.5,-524 -292.5,-1134 2304.5,-1134 6309.5,-1134 6309.5,-524
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 6102,-318 h25
  text ".VariantName" at 5058,-434 h25
  text "ASSEMBLY VARIANT:" at 6097,-434 h25
  text ".VersionControl_RevNumber" at 1035.5,-656.17 h25
  text "SVN REV:" at 1541.5,-656.17 h25
  text ".PCB_Rev" at 2088,-656.17 h25
  text "REV:" at 2379.5,-656.17 h25
  text ".PRJ_Number" at 3224,-656.17 h25
  text "BOARD #:" at 3769.5,-656.17 h25
  text "PCB VIEWED FROM BOTTOM SIDE" at 6246,-656.17 h25
  text ".TID" at 3224,-859.5 h25
  text "TID #:" at 3769.5,-859.5 h25
  text "TEXAS INSTRUMENTS" at 904.5,-1064.84 h25
  text ".Print_Time" at 2169,-1064.84 h25
  text ".Print_Date" at 2898,-1064.84 h25
  text "GENERATED    :" at 3767.5,-1064.84 h25
  text ".plot_File_Name" at 5440.5,-1064.84 h25
  text "PLOT NAME =" at 6246,-1064.84 h25
M9 Title Sheet:
  lines w10: -491.5,1041.5 -291.5,1041.5 ; -491.5,3416.5 -291.5,3416.5 ; -491.5,5791.5 -291.5,5791.5 ; 2008.5,-1333.5 2008.5,-1133.5 ; 2008.5,7966.5 2008.5,8166.5 ; 4508.5,-1333.5 4508.5,-1133.5 ; 4508.5,7966.5 4508.5,8166.5 ; 6321,-1133.5 6321,-523.5 11303.5,-523.5 ; 7008.5,-1333.5 7008.5,-1133.5 ; 7008.5,7966.5 7008.5,8166.5 ; 9508.5,-1333.5 9508.5,-1133.5 ; 9508.5,7966.5 9508.5,8166.5 ; 11303.5,-1133.5 11303.5,-523.5 ; 11303.5,-823.5 14303.5,-823.5 ; 11303.5,-223.5 14303.5,-223.5 ; 11304.5,370.5 14304.5,370.5 ; 12008.5,-1333.5 12008.5,-1133.5 ; 12008.5,7966.5 12008.5,8166.5 ; 12808.5,-1123.5 12808.5,-523.5 ; 14303.5,-523.5 11303.5,-523.5 ; 14303.5,76.5 11303.5,76.5 ; 14308.5,66.5 14308.5,-1133.5 ; 14308.5,871 11304.5,871 11303.5,871 11303.5,370.5 11303.5,76.5 ; 14308.5,1041.5 14508.5,1041.5 ; 14308.5,3416.5 14508.5,3416.5 ; 14308.5,5791.5 14508.5,5791.5 ; 11303.5,-523.5 11303.5,76.5 ; 14308.5,-1133.5 14308.5,7966.5 -291.5,7966.5 -291.5,-1133.5 14308.5,-1133.5 ; -491.5,-1333.5 -491.5,8166.5 14508.5,8166.5 14508.5,-1333.5 -491.5,-1333.5
  text "1" at 739.84,8036.5 h25
  text "2" at 3235.5,8036.5 h25
  text "3" at 5724.84,8036.5 h25
  text "4" at 8231.51,8036.5 h25
  text "5" at 10730.5,8036.5 h25
  text "6" at 13235.5,8036.5 h25
  text "A" at -416.5,6893.5 h25
  text "A" at 14383.5,6893.5 h25
  text "B" at -416.5,4513.5 h25
  text "B" at 14383.5,4513.5 h60
  text "C" at -416.5,2138.5 h25
  text "C" at 14383.5,2138.5 h60
  text "PROJECT TITLE:" at 11343.5,277.5 h60
  text "DRV81008-Q1EVM_A" at 11393.5,144.17 h60
  text "DESIGNED FOR:" at 11343.5,-23.5 h60
  text ".PRJ_Customer" at 11393.5,-163.5 h60
  text "D" at -416.5,-231.5 h25
  text "D" at 14383.5,-231.5 h60
  text "FILE NAME:" at 11343.5,-323.5 h60
  text ".PCB_File_Name_No_Path" at 11393.5,-443.5 h60
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 6374,-605.34 h25
  text "ENGINEER:" at 11343.5,-613.5 h60
  text "LAYOUT BY:" at 12848.5,-613.5 h60
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 6329.01,-718 h25
  text ".PRJ_Engineer" at 11393.5,-768.49 h60
  text ".PCB_Layout" at 12899,-768.49 h60
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 6329.01,-830.67 h25
  text ".Layer_Name" at 577,-858.49 h50
  text "ALTIUM DESIGNER VERSION:" at 12848.5,-923.5 h60
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 6329.01,-943.33 h25
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 6374,-1056 h25
  text ".print_Scale" at 11393.5,-1056.83 h60
  text ".Application_BuildNumber" at 12899,-1056.83 h60
  text "1" at 739.84,-1263.5 h25
  text "2" at 3235.5,-1263.5 h25
  text "3" at 5724.84,-1263.5 h25
  text "4" at 8231.51,-1263.5 h25
  text "5" at 10730.5,-1263.5 h60
  text "6" at 13235.5,-1263.5 h60
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 12382.02,6356.17 h60
  text "MIN. TRACK WIDTH:" at 11737.46,6224.05 h60
  text "5" at 12833.7,6224.05 h60
  text "MIL" at 12988.46,6224.05 h60
  text "MIN. CLEARANCE:" at 11737.46,6099.92 h60
  text "0.2" at 12773.7,6099.93 h60
  text "mm" at 12988.46,6099.92 h60
  text "MIN. VIA PAD SIZE:" at 11737.46,5975.8 h60
  text "16" at 12803.71,5975.8 h60
  text "MIL" at 12988.46,5975.8 h60
  text "0.05mm (2MIL)" at 12432.46,5845.9 h60
  text "MINIMUM ANNULAR RING" at 11408.23,5837.67 h60
  text "EXTERNAL" at 13140.46,5837.67 h60
  text "PER" at 11608.23,5727.55 h60
  text "IPC-D-275 CLASS 2 LEVEL C" at 11828.23,5727.54 h60
  text "MIL, HOLES" at 13316.46,5627.07 h60
  text "+/-" at 12924,5618.48 h60
  text "+/-" at 13778,5618.48 h60
  text "REGISTRATION TOLERANCES:" at 11408.23,5617.42 h60
  text "METAL" at 12608,5617.42 h60
  text "5" at 13184.2,5617.42 h60
  text "3" at 14017.2,5617.42 h60
  text "MIL" at 14133.46,5617.42 h60
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 11408.23,5519.1 h60
  text "+/-" at 13778,5516.23 h60
  text "3" at 14017.2,5515.17 h60
  text "MIL" at 14133.46,5515.17 h60
  text "MATERIAL:" at 11333.46,5377.52 h60
  text "FR-4 High Tg" at 12319.9,5249 h60
  text "X" at 12175.46,5241.01 h60
  text "FR-408" at 11754.46,5236.49 h60
  text "OTHER" at 13242.46,5236.49 h60
  text "62 MIL (1.6mm) +/-10%" at 12074.56,5093.46 h60
  text "X" at 11954.46,5091.01 h60
  text "THICKNESS:" at 11408.23,5085.24 h60
  text "OTHER" at 13359.46,5085.24 h60
  text "TOLERANCE:" at 11408.23,4946.92 h60
  text "X" at 12256.46,4946.92 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4946.92 h60
  text "OTHER +/-" at 12434.46,4802.73 h60
  text "BOW & TWIST:" at 11408.23,4657.54 h60
  text "X" at 12256.46,4657.54 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4657.54 h60
  text "OTHER +/-" at 12434.46,4510.85 h60
  text "DRILLING:" at 11333.46,4380.23 h60
  text "NC_DRILL FILES" at 13094.46,4275.04 h60
  text "REFERENCE:" at 11408.23,4271.1 h60
  text "X" at 12065.46,4271.01 h60
  text "AS SHOWN" at 12243.46,4271.1 h60
  text "X" at 12966.46,4271.1 h60
  text "OTHER" at 13392.46,4128.85 h60
  text "PTH COPPER THICKNESS:" at 11407.91,4125.32 h60
  text "X" at 12547.14,4125.32 h60
  text "20-30 um" at 12675.14,4125.32 h60
  text "BOARD FINISH:" at 11333.46,3977.73 h60
  text "SILKSCREEN:" at 11488.68,3867.6 h60
  text "X" at 12446.46,3867.6 h60
  text "TOP" at 12563.46,3867.6 h60
  text "X" at 12956.46,3867.6 h60
  text "BOTTOM" at 13074.46,3867.6 h60
  text "SILKSCREEN COLOR:" at 11488.68,3712.41 h60
  text "X" at 12445.46,3712.41 h60
  text "WHITE" at 12563.46,3712.41 h60
  text "OTHER" at 13074.46,3712.41 h60
  text "X" at 12576.46,3568.96 h60
  text "GREEN" at 12694.46,3568.96 h60
  text "OTHER" at 13312.46,3568.96 h60
  text "SOLDER RESIST COLOR:" at 11488.68,3562.1 h60
  text "X" at 12576.46,3414.71 h60
  text "MATTE" at 12694.46,3414.71 h60
  text "SEMI-GLOSS" at 13312,3414.07 h60
  text "IMMERSION GOLD (ENIG)" at 12394.46,3241.94 h60
  text "ENEPIG" at 13732,3234.72 h60
  text "SURFACE FINISH:" at 11333.46,3233.72 h60
  text "X" at 12216.46,3233.72 h60
  text "IMM. TIN/SILVER OR EQUIV" at 11663,3096.4 h60
  text "OTHER" at 13094.46,3092.47 h60
  text "ARRAY/PANEL:" at 11333.46,2937.09 h60
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 12394.46,2928.87 h60
  text "X" at 12212.46,2925.9 h60
  text "N.C. ROUTE" at 12394.46,2792.9 h60
  text "V. SCORE" at 13260.46,2792.9 h60
  text "CERTIFICATION:" at 11333.46,2663.77 h60
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 12058.46,2663.77 h60
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 12058.46,2569.71 h60
  text "X" at 11695.97,2441.08 h60
  text "ANSI IPC-A-600F CLASS ->" at 11823.96,2441.08 h60
  text "X" at 13471.97,2441.08 h60
  text "2" at 13581.96,2441.08 h60
  text "1" at 13266.96,2439.58 h60
  text "3" at 13935.96,2439.58 h60
  text "X" at 12507.97,2293.39 h60
  text "RoHS" at 12635.96,2293.39 h60
  text "OTHER" at 13280.36,2293.39 h60
  text "PER ORDER" at 13677.42,2293.39 h60
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 11361,2139.57 h60
  text "FAB NOTES:" at 5443.93,2096.41 h55
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 11361,2023.5 h60
  text "1. NO VENDOR LOGO OR NAME ON THE BOARD." at 5442.93,1969.72 h55
  text "ADDITIONAL REQUIREMENTS:" at 11333.46,1854.08 h60
  text "2. ALL HOLES SHOULD BE FHS." at 5442.93,1847.09 h55
  text "MICROSECTION:" at 11408.23,1746.95 h60
  text "YES" at 12313.96,1746.95 h60
  text "3. CLIP SILK ON NO MASK AREA." at 5446.93,1726.89 h55
  text "4. 7.87MIL DRILLS NEED TO BE NON-CONDUCTIVE SOLDER MASK PLUGGING FROM BOTTOM SIDE" at 5445,1639 h55
  text "REQUIRED" at 13175.46,1602.62 h60
  text "BARE BOARD ELEC. TEST:" at 11408.23,1599.76 h60
  text "NONE" at 12713.96,1599.76 h60
  text "X" at 13057.46,1599.76 h60
  text "PER ORDER" at 13767.46,1599.76 h60
  text "5.REMOVE NON-FUNCTINAL PADS IN INNER LAYER ." at 5448,1543 h55
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 11576.38,1394.82 h60
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 11584.38,1290.84 h60
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 11583.39,1127.46 h55
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 11575.39,891.74 h60
  text ".Layer_Name" at 577,-858.49 h50
M11 Gerber Information:
  circle w10: c4559,4935.91 r70
  circle w10: c4559,4935.91 r40
  circle w10: c4587,1286.91 r70
  circle w10: c4587,1286.91 r40
  circle w10: c-46,1274.91 r70
  circle w10: c-46,1274.91 r40
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; -146,1274.91 54,1274.91 ; -46,1174.91 -46,1374.91 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4459,4935.91 4659,4935.91 ; 4487,1286.91 4687,1286.91 ; 4559,4835.91 4559,5035.91 ; 4587,1186.91 4587,1386.91 ; 4902,-1140 4902,-937.17
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -228.5,-655.67 h50
  text "BOARD #:" at 2248,-655.67 h50
  text "REV:" at 3638,-655.67 h50
  text "A" at 3929.5,-655.67 h50
  text "SVN REV:" at 4476,-655.67 h50
  text ".VersionControl_RevNumber" at 4982,-655.67 h50
  text "DRV81008-Q1EVM_A" at 2634,-659 h50
  text "LAYER NAME =" at -228.5,-858.49 h50
  text "TID #:" at 2248,-859 h50
  text ".TID" at 2793.5,-859 h50
  text ".plot_File_Name" at 339,-1059 h35
  text "PLOT NAME =" at -228.5,-1064.34 h50
  text "GENERATED    :" at 2250,-1064.34 h50
  text ".Print_Date" at 3119.5,-1064.34 h50
  text ".Print_Time" at 3848.5,-1064.34 h50
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h50
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Stackup:" at 5517,6145.33 h70
  text "Layer" at 5576.4,6007.62 h60
  text "Name" at 5986.31,6007.62 h60
  text "Material" at 6926.05,6007.62 h60
  text "Thickness" at 7785.82,6007.62 h60
  text "Constant" at 8435.66,6007.62 h60
  text "Board Layer Stack" at 9005.52,6007.62 h60
  text "Top Overlay" at 5986.31,5887.62 h60
  text "Top Solder" at 5986.31,5767.62 h60
  text "Solder Resist" at 6926.05,5767.62 h60
  text "0.40mil" at 7785.82,5767.62 h60
  text "3.5" at 8435.66,5767.62 h60
  text "1" at 5576.4,5647.62 h60
  text "Top Layer" at 5986.31,5647.62 h60
  text "2.80mil" at 7785.82,5647.62 h60
  text "Dielectric 1" at 5986.31,5527.62 h60
  text "FR-4 High Tg" at 6926.05,5527.62 h60
  text "11.40mil" at 7785.82,5527.62 h60
  text "4.2" at 8435.66,5527.62 h60
  text "2" at 5576.4,5407.62 h60
  text "Signal Layer 1" at 5986.31,5407.62 h60
  text "1.40mil" at 7785.82,5407.62 h60
  text "Dielectric 2" at 5986.31,5287.62 h60
  text "FR-4 High Tg" at 6926.05,5287.62 h60
  text "30.00mil" at 7785.82,5287.62 h60
  text "4.2" at 8435.66,5287.62 h60
  text "3" at 5576.4,5167.62 h60
  text "Signal Layer 2" at 5986.31,5167.62 h60
  text "1.40mil" at 7785.82,5167.62 h60
  text "Dielectric 3" at 5986.31,5047.62 h60
  text "FR-4 High Tg" at 6926.05,5047.62 h60
  text "11.40mil" at 7785.82,5047.62 h60
  text "4.2" at 8435.66,5047.62 h60
  text "4" at 5576.4,4927.62 h60
  text "Bottom Layer" at 5986.31,4927.62 h60
  text "2.80mil" at 7785.82,4927.62 h60
  text "Bottom Solder" at 5986.31,4807.62 h60
  text "Solder Resist" at 6926.05,4807.62 h60
  text "0.40mil" at 7785.82,4807.62 h60
  text "3.5" at 8435.66,4807.62 h60
  text "Bottom Overlay" at 5986.31,4687.62 h60
  text ".Layer_Name" at 577,-858.49 h50
M13 Component Bodies Top:
  text ".Layer_Name" at 577,-858.49 h50
M14 Component Bodies Bottom:
  text ".Layer_Name" at 577,-858.49 h50
M15 Courtyards Top:
  text ".Layer_Name" at 577,-858.49 h50
M16 Courtyards Bottom:
  text ".Layer_Name" at 577,-858.49 h50
Drill Drawing:
  circle w10: c5114.93,4329.62 r12.01
  circle w10: c5114.93,4329.62 r20.02
  circle w10: c5114.93,3609.02 r20.02
  lines w10: 5094.91,3228.7 5134.94,3228.7 5134.94,3268.73 5094.91,3268.73 5094.91,3228.7 ; 5094.91,3318.77 5134.94,3318.77 5134.94,3358.81 5094.91,3358.81 5094.91,3318.77 ; 5094.91,3418.86 5104.92,3418.86 5114.93,3408.85 5124.94,3418.86 5134.94,3418.86 5124.94,3428.86 5134.94,3438.87 5124.94,3438.87 5114.93,3448.88 5104.92,3438.87 5094.91,3438.87 5104.92,3428.86 5094.91,3418.86 ; 5094.91,3498.92 5114.93,3508.93 5134.94,3498.92 5124.94,3518.94 5134.94,3538.96 5114.93,3528.95 5094.91,3538.96 5104.92,3518.94 5094.91,3498.92 ; 5094.91,3719.11 5134.94,3719.11 5114.93,3679.08 5094.91,3719.11 ; 5094.91,3779.16 5104.92,3779.16 5104.92,3769.15 5124.94,3769.15 5124.94,3779.16 5134.94,3779.16 5134.94,3799.18 5124.94,3799.18 5124.94,3809.19 5104.92,3809.19 5104.92,3799.18 5094.91,3799.18 5094.91,3779.16 ; 5094.91,3879.24 5114.93,3859.23 5134.94,3879.24 5114.93,3899.26 5094.91,3879.24 ; 5094.91,3949.3 5114.93,3959.31 5134.94,3949.3 5124.94,3969.32 5134.94,3989.34 5114.93,3979.33 5094.91,3989.34 5104.92,3969.32 5094.91,3949.3 ; 5094.91,4039.38 5094.91,4049.39 5104.92,4059.4 5094.91,4069.41 5094.91,4079.41 5104.92,4079.41 5114.93,4069.41 5124.94,4079.41 5134.94,4079.41 5134.94,4069.41 5124.94,4059.4 5134.94,4049.39 5134.94,4039.38 5124.94,4039.38 5114.93,4049.39 5104.92,4039.38 5094.91,4039.38 ; 5094.91,4139.46 5104.92,4139.46 5114.93,4129.46 5124.94,4139.46 5134.94,4139.46 5124.94,4149.47 5134.94,4159.48 5124.94,4159.48 5114.93,4169.49 5104.92,4159.48 5094.91,4159.48 5104.92,4149.47 5094.91,4139.46 ; 5094.91,4229.54 5104.92,4229.54 5104.92,4219.53 5124.94,4219.53 5124.94,4229.54 5134.94,4229.54 5134.94,4249.56 5124.94,4249.56 5124.94,4259.57 5104.92,4259.57 5104.92,4249.56 5094.91,4249.56 5094.91,4229.54 ; 5102.92,3326.78 5126.94,3326.78 5126.94,3350.8 5102.92,3350.8 5102.92,3326.78 ; 5102.92,3506.93 5114.93,3512.94 5126.94,3506.93 5120.93,3518.94 5126.94,3530.95 5114.93,3524.95 5102.92,3530.95 5108.92,3518.94 5102.92,3506.93 ; 5102.92,3783.16 5108.92,3783.16 5108.92,3777.16 5120.93,3777.16 5120.93,3783.16 5126.94,3783.16 5126.94,3795.17 5120.93,3795.17 5120.93,3801.18 5108.92,3801.18 5108.92,3795.17 5102.92,3795.17 5102.92,3783.16 ; 5102.92,4143.47 5108.92,4143.47 5114.93,4137.46 5120.93,4143.47 5126.94,4143.47 5120.93,4149.47 5126.94,4155.48 5120.93,4155.48 5114.93,4161.48 5108.92,4155.48 5102.92,4155.48 5108.92,4149.47 5102.92,4143.47
  lines w12: 5057.76,3201.67 10482.21,3201.67 ; 5057.76,4372.66 10482.21,4372.66 ; 5401.34,3111.6 5401.34,4462.74 ; 5797.15,3111.6 5797.15,4462.74 ; 6617.98,3111.6 6617.98,4462.74 ; 6934.54,3111.6 6934.54,4462.74 ; 7387.98,3111.6 7387.98,4462.74 ; 8296.46,3111.6 8296.46,4462.74 ; 8958.8,3111.6 8958.8,4462.74 ; 9627.16,3111.6 9627.16,4462.74 ; 5057.76,3111.6 10482.21,3111.6 10482.21,4462.74 5057.76,4462.74 5057.76,3111.6
  text "Drill Drawing :" at 5093,4495.99 h60
  text "Symbol" at 5111.8,4399.68 h43.24
  text "Quantity" at 5428.37,4399.68 h43.24
  text "Finished Hole Size" at 5824.17,4399.68 h43.24
  text "Plated" at 6645,4399.68 h43.24
  text "Hole Type" at 6961.57,4399.68 h43.24
  text "Drill Layer Pair" at 7415,4399.68 h43.24
  text "Hole Tolerance" at 8323.48,4399.68 h43.24
  text "Hole Length" at 8985.83,4399.68 h43.24
  text "Routed Path Length" at 9654.18,4399.68 h43.24
  text "37" at 5428.37,4309.61 h36.03
  text "7.87mil (0.200mm)" at 5824.17,4309.61 h36.03
  text "PTH" at 6645,4309.61 h36.03
  text "Round" at 6961.57,4309.61 h36.03
  text "Top Layer - Bottom Layer" at 7415,4309.61 h36.03
  text "+3mil/-3mil" at 8323.48,4309.61 h36.03
  text "-" at 8985.83,4309.61 h36.03
  text "-" at 9654.18,4309.61 h36.03
  text "62" at 5428.37,4219.53 h36.03
  text "8.00mil (0.203mm)" at 5824.17,4219.53 h36.03
  text "PTH" at 6645,4219.53 h36.03
  text "Round" at 6961.57,4219.53 h36.03
  text "Top Layer - Bottom Layer" at 7415,4219.53 h36.03
  text "+3mil/-3mil" at 8323.48,4219.53 h36.03
  text "-" at 8985.83,4219.53 h36.03
  text "-" at 9654.18,4219.53 h36.03
  text "11" at 5428.37,4129.46 h36.03
  text "10.00mil (0.254mm)" at 5824.17,4129.46 h36.03
  text "PTH" at 6645,4129.46 h36.03
  text "Round" at 6961.57,4129.46 h36.03
  text "Top Layer - Bottom Layer" at 7415,4129.46 h36.03
  text "+3mil/-3mil" at 8323.48,4129.46 h36.03
  text "-" at 8985.83,4129.46 h36.03
  text "-" at 9654.18,4129.46 h36.03
  text "179" at 5428.37,4039.38 h36.03
  text "16.00mil (0.406mm)" at 5824.17,4039.38 h36.03
  text "PTH" at 6645,4039.38 h36.03
  text "Round" at 6961.57,4039.38 h36.03
  text "Top Layer - Bottom Layer" at 7415,4039.38 h36.03
  text "+3mil/-3mil" at 8323.48,4039.38 h36.03
  text "-" at 8985.83,4039.38 h36.03
  text "-" at 9654.18,4039.38 h36.03
  text "7" at 5428.37,3949.3 h36.03
  text "17.72mil (0.450mm)" at 5824.17,3949.3 h36.03
  text "PTH" at 6645,3949.3 h36.03
  text "Round" at 6961.57,3949.3 h36.03
  text "Top Layer - Bottom Layer" at 7415,3949.3 h36.03
  text "+3mil/-3mil" at 8323.48,3949.3 h36.03
  text "-" at 8985.83,3949.3 h36.03
  text "-" at 9654.18,3949.3 h36.03
  text "34" at 5428.37,3859.23 h36.03
  text "40.00mil (1.016mm)" at 5824.17,3859.23 h36.03
  text "PTH" at 6645,3859.23 h36.03
  text "Round" at 6961.57,3859.23 h36.03
  text "Top Layer - Bottom Layer" at 7415,3859.23 h36.03
  text "+3mil/-3mil" at 8323.48,3859.23 h36.03
  text "-" at 8985.83,3859.23 h36.03
  text "-" at 9654.18,3859.23 h36.03
  text "28" at 5428.37,3769.15 h36.03
  text "43.31mil (1.100mm)" at 5824.17,3769.15 h36.03
  text "PTH" at 6645,3769.15 h36.03
  text "Round" at 6961.57,3769.15 h36.03
  text "Top Layer - Bottom Layer" at 7415,3769.15 h36.03
  text "+3mil/-3mil" at 8323.48,3769.15 h36.03
  text "-" at 8985.83,3769.15 h36.03
  text "-" at 9654.18,3769.15 h36.03
  text "3" at 5428.37,3679.08 h36.03
  text "45.28mil (1.150mm)" at 5824.17,3679.08 h36.03
  text "PTH" at 6645,3679.08 h36.03
  text "Round" at 6961.57,3679.08 h36.03
  text "Top Layer - Bottom Layer" at 7415,3679.08 h36.03
  text "+3mil/-3mil" at 8323.48,3679.08 h36.03
  text "-" at 8985.83,3679.08 h36.03
  text "-" at 9654.18,3679.08 h36.03
  text "22" at 5428.37,3589 h36.03
  text "51.18mil (1.300mm)" at 5824.17,3589 h36.03
  text "PTH" at 6645,3589 h36.03
  text "Round" at 6961.57,3589 h36.03
  text "Top Layer - Bottom Layer" at 7415,3589 h36.03
  text "+3mil/-3mil" at 8323.48,3589 h36.03
  text "-" at 8985.83,3589 h36.03
  text "-" at 9654.18,3589 h36.03
  text "2" at 5428.37,3498.92 h36.03
  text "59.06mil (1.500mm)" at 5824.17,3498.92 h36.03
  text "PTH" at 6645,3498.92 h36.03
  text "Round" at 6961.57,3498.92 h36.03
  text "Top Layer - Bottom Layer" at 7415,3498.92 h36.03
  text "+3mil/-3mil" at 8323.48,3498.92 h36.03
  text "-" at 8985.83,3498.92 h36.03
  text "-" at 9654.18,3498.92 h36.03
  text "22" at 5428.37,3408.85 h36.03
  text "63.00mil (1.600mm)" at 5824.17,3408.85 h36.03
  text "PTH" at 6645,3408.85 h36.03
  text "Round" at 6961.57,3408.85 h36.03
  text "Top Layer - Bottom Layer" at 7415,3408.85 h36.03
  text "+3mil/-3mil" at 8323.48,3408.85 h36.03
  text "-" at 8985.83,3408.85 h36.03
  text "-" at 9654.18,3408.85 h36.03
  text "2" at 5428.37,3318.77 h36.03
  text "25.59mil (0.650mm)" at 5824.17,3318.77 h36.03
  text "PTH" at 6645,3318.77 h36.03
  text "Slot" at 6961.57,3318.77 h36.03
  text "Top Layer - Bottom Layer" at 7415,3318.77 h36.03
  text "+3mil/-3mil" at 8323.48,3318.77 h36.03
  text "29.53mil (0.750mm)" at 8985.83,3318.77 h36.03
  text "3.94mil (0.100mm)" at 9654.18,3318.77 h36.03
  text "2" at 5428.37,3228.7 h36.03
  text "51.18mil (1.300mm)" at 5824.17,3228.7 h36.03
  text "PTH" at 6645,3228.7 h36.03
  text "Slot" at 6961.57,3228.7 h36.03
  text "Top Layer - Bottom Layer" at 7415,3228.7 h36.03
  text "+3mil/-3mil" at 8323.48,3228.7 h36.03
  text "29.53mil (0.750mm)" at 8985.83,3228.7 h36.03
  text "-21.65mil (-0.550mm)" at 9654.18,3228.7 h36.03
  text "411 Total" at 5428.37,3138.62 h36.03
  text "Slot definitions :" at 5111.8,3043.57 h36.03
  text "Routed Path Length" at 5743.13,3043.57 h36.03
  text "= Calculated from tool start centre position to tool end centre position." at 6416.47,3043.57 h36.03
  text "Hole Length" at 5743.13,2975.55 h36.03
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 6170.34,2975.55 h36.03
  text ".Layer_Name" at 577,-858.49 h50
Mechanical 17:
  text ".Layer_Name" at 577,-858.49 h50
Mechanical 18:
  text ".Layer_Name" at 577,-858.49 h50
Mechanical 19:
  text ".Layer_Name" at 577,-858.49 h50