# Altium project OLD_DRV81080-Q1EVM_A.PrjPCB (part 2 of 2)

## Sheet OLD_MD081E1_MCU.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Tilden Chen; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 2; Revision: Use project parameter SCH_Rev; SheetNumber: 2; SheetTotal: 3; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C15  Cap_F: 100nF  VDC_V: 50V  [0603]  (hidden comment: 885012206095)
C41  ValueDisplayed: 1nF  VDC_V: 100V  [FP-885012006085_0603-MFG]  (hidden comment: 885012006085)
C44  VDC_V: 50V  ValueDisplayed: 10pF  [0402]  (hidden comment: 885012005055)
C45  VDC_V: 50V  ValueDisplayed: 10pF  [0402]  (hidden comment: 885012005055)
C46  Cap_F: 100nF  VDC_V: 50V  [0603]  (hidden comment: 885012206095)
C49  VDC_V: 16V  Cap_F: 470nF  [FP-885012206050_0603-MFG]  (hidden comment: 885012206050)
C50  Cap_F: 100nF  VDC_V: 50V  [0603]  (hidden comment: 885012206095)
C51  ValueDisplayed: 10uF  VDC_V: 10V  [FP-875105240001_SMT_CAP_4MM3_4MM3-MFG]  (hidden comment: 875105240001)
C52  Cap_F: 100nF  VDC_V: 50V  [0603]  (hidden comment: 885012206095)
C53  Cap_F: 100nF  VDC_V: 50V  [0603]  (hidden comment: 885012206095)
C54  Cap_F: 100nF  VDC_V: 50V  [0603]  (hidden comment: 885012206095)
C59  ValueDisplayed: 1nF  VDC_V: 100V  [FP-885012006085_0603-MFG]  (hidden comment: 885012006085)
D3  Color: Red  [FP-150080SS75000-MFG]  (hidden comment: 150080SS75000)
D5  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D6  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D8  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D10  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D11  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D12  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D13  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D14  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D15  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D16  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D17  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D18  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
D19  Color: Bright Green  [0805_A]  (hidden comment: 150080VS75000)
J6  61300311121  [WURTH_61300311121]  (value not drawn)
J7  PEC10DAAN  [SULLINS_PEC10DAAN]
R9  value 10  [FP-560050310009_0402-MFG]  (hidden comment: 560050310009)
R18  ValueDisplayed: 47k  [0402]  (hidden comment: CRCW040247K0JNED)
R19  ValueDisplayed: 47k  [0402]  (hidden comment: CRCW040247K0JNED)
R30  ValueDisplayed: 10k  [0603L]  (hidden comment: RC0603JR-0710KL)
R31  ValueDisplayed: 10k  [0603L]  (hidden comment: RC0603JR-0710KL)
R32  ValueDisplayed: 10k  [0603L]  (hidden comment: RC0603JR-0710KL)
R37  value 10  [FP-560050310009_0402-MFG]  (hidden comment: 560050310009)
R39  ValueDisplayed: 10k  [0603L]  (hidden comment: RC0603JR-0710KL)
R40  ValueDisplayed: 10k  [0603L]  (hidden comment: RC0603JR-0710KL)
R41  ValueDisplayed: 10k  [0603L]  (hidden comment: RC0603JR-0710KL)
R43  ValueDisplayed: 4.99k  [0603L]  (hidden comment: CRCW06034K99FKEAC)
R45  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R47  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R48  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R49  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R51  ValueDisplayed: 10k  [0603L]  (hidden comment: RC0603JR-0710KL)
R52  ValueDisplayed: 10k  [0603L]  (hidden comment: RC0603JR-0710KL)
R53  ValueDisplayed: 10k  [0603L]  (hidden comment: RC0603JR-0710KL)
R54  ValueDisplayed: 10k  [0603L]  (hidden comment: RC0603JR-0710KL)
R80  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R81  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R82  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R83  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R84  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R85  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R86  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R87  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R88  ValueDisplayed: 330  [0603L]  (hidden comment: Resistor)
R90  ValueDisplayed: 100  [0402S]  (hidden comment: RC0402FR-07100RL)
R91  ValueDisplayed: 100  [0402S]  (hidden comment: RC0402FR-07100RL)
R92  ValueDisplayed: 100  [0402S]  (hidden comment: RC0402FR-07100RL)
R93  ValueDisplayed: 100  [0402S]  (hidden comment: RC0402FR-07100RL)
R94  value 100  [0402S]  (hidden comment: RC0402FR-07100RL)
R95  ValueDisplayed: 100  [0402S]  (hidden comment: RC0402FR-07100RL)
R96  RC0402FR-07100RL  [0402S]  (value not drawn)
S1  430481025816  [FP-430481025816_SMT_SW_6MM2_6MM2-MFG]
SH-J1  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J6  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J7  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J8  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J9  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J10  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J11  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J12  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J19  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J36  60900213421  [Wurth_60900213421]  (value not drawn)
TP19  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP20  5002  [Keystone5002]  (value not drawn)
TP21  5002  [Keystone5002]  (value not drawn)
TP22  5002  [Keystone5002]  (value not drawn)
TP23  5002  [Keystone5002]  (value not drawn)
TP24  5002  [Keystone5002]  (value not drawn)
TP25  5002  [Keystone5002]  (value not drawn)
TP26  5002  [Keystone5002]  (value not drawn)
TP27  5002  [Keystone5002]  (value not drawn)
TP28  5002  [Keystone5002]  (value not drawn)
TP29  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP30  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP31  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP32  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP33  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP34  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP35  5011  [Keystone5011]  (value not drawn)
TP36  5003  [Keystone5003]  (value not drawn)
U1  MSP430F5338IPZ  [PZT0100A_N]
Y2  MS3V-T1R 32.768KHZ +/-20PPM 12.5PF  [XTAL_MS3V-T1R]  (value not drawn)

### Blocks framed on the sheet
MSP430: C15 C41 C44-C46 C49-C54 R9 R18 R37 TP29-TP36 U1 Y2

### Nets
GND: C15.2 C41.1 C44.2 C45.2 C46.1 C49.1 C50.2 C51.1(CATHODE) C52.2 C53.2 C54.2 C59.1 J7.2 R30.2 R32.2 R43.1 R45.1 R47.1 R48.1 R49.1 R51.2 R52.2 R53.2 R80.1 R81.1 R82.1 R83.1 R84.1 R85.1 R86.1 R87.1 R88.1 S1.3 S1.4 TP35.1 U1.10(P5.1/VREF-/VEREF-) U1.12(AVSS1) U1.15(AVSS2) U1.26(DVSS1) U1.29(DVSS) U1.63(DVSS2) U1.76(VSSU) U1.83(AVSS3) U1.90(DVSS3) Y2.3(GND)
MCU_3V3: C46.2 C51.2(ANODE) C52.1 C53.1 C54.1 D5.2(A) J7.4 R9.2 R18.1 R19.2 R31.1 R37.1 R39.1 R40.1 R41.1 R54.1 TP36.1 U1.25(DVCC1) U1.64(DVCC2) U1.87(VBAT) U1.89(DVCC3)
VS: D6.2(A)  [also labelled VBAT]
CHANNEL_0: D15.2(A) U1.50(P4.0/TB0.0)
CHANNEL_1: D19.2(A) U1.51(P4.1/TB0.1)
CHANNEL_2: D14.2(A) U1.52(P4.2/TB0.2)
CHANNEL_3: D18.2(A) U1.53(P4.3/TB0.3)
CHANNEL_4: D13.2(A) U1.54(P4.4/TB0.4)
CHANNEL_5: D17.2(A) U1.55(P4.5/TB0.5)
CHANNEL_6: D12.2(A) U1.56(P4.6/TB0.6)
CHANNEL_7: D16.2(A) U1.57(P4.7/TB0OUTH/SVMOUT)
DRV_STATUS: D11.2(A) U1.35(P1.1/TA0.0)
FAULT_STATUS: D3.2(A) U1.22(P2.5/P2MAP5)
GUI_STATUS: D10.2(A) U1.34(P1.0/TA0CLK/ACLK)
ID0: R39.2 R51.1 U1.43(P3.1/TA1.0)
ID1: R40.2 R52.1 U1.44(P3.2/TA1.1)
ID2: R41.2 R53.1 U1.45(P3.3/TA1.2)
ID3: R30.1 R54.2 U1.46(P3.4/TA2CLK/SMCLK)
ID4: R31.2 R32.1 U1.47(P3.5/TA2.0)
IN0: J7.5 TP22.1
IN0_MCU: R94.1 U1.69(P9.1)
IN1: J7.7 TP23.1
IN1_MCU: R95.1 U1.70(P9.2)
MCU_STATUS: D8.2(A) TP19.1 U1.37(P1.3/TA0.2)
MCU_UARTRXD: U1.61(P8.3/UCA1RXD/UCA1SOMI)
MCU_UARTTXD: U1.60(P8.2/UCA1TXD/UCA1SIMO)
nSCS: J7.19 TP28.1
nSCS_MCU: R90.1 U1.67(P8.7)
nSLEEP: J7.9 TP24.1
nSLEEP_MCU: R96.1 U1.71(P9.3)
PUSH: J6.3 U1.36(P1.2/TA0.1)
RST/SBWTDIO: C41.2 C59.2 J6.1 R18.2 R19.1 U1.96(~{RST}/NMI/SBWTDIO)
SCLK: J7.17 TP27.1
SCLK_MCU: R93.1 U1.62(P8.4/UCB1CLK/UCA1STE)
SDI: J7.15 TP26.1
SDI_MCU: R91.1 U1.65(P8.5/UCB1SIMO/UCB1SDA)
SDO: J7.13 TP25.1
SDO_MCU: R92.1 U1.66(P8.6/UCB1SOMI/UCB1SCL)
TST/SBWTCK: U1.91(TEST/SBWTCK)
VBAT_MON: U1.97(P6.0/CB0/A0)
NetC15_1: C15.1 R9.1 U1.9(P5.0/VREF+/VEREF+)
NetC44_1: C44.1 U1.14(XOUT) Y2.1
NetC45_1: C45.1 U1.13(XIN) Y2.2
NetC49_2: C49.2 U1.27(VCORE)
NetC50_1: C50.1 R37.2 U1.11(AVCC1)
NetD3_1: D3.1(C) R80.2
NetD5_1: D5.1(K) R49.2
NetD6_1: D6.1(K) R43.2
NetD8_1: D8.1(K) R45.2
NetD10_1: D10.1(K) R47.2
NetD11_1: D11.1(K) R48.2
NetD12_1: D12.1(K) R81.2
NetD13_1: D13.1(K) R82.2
NetD14_1: D14.1(K) R83.2
NetD15_1: D15.1(K) R84.2
NetD16_1: D16.1(K) R85.2
NetD17_1: D17.1(K) R86.2
NetD18_1: D18.1(K) R87.2
NetD19_1: D19.1(K) R88.2
NetJ6_2: J6.2 S1.1 S1.2
NetJ7_1: J7.1 TP20.1
NetJ7_3: J7.3 TP21.1
NetJ7_6: J7.6 R94.2
NetJ7_8: J7.8 R95.2
NetJ7_10: J7.10 R96.2
NetJ7_14: J7.14 R92.2
NetJ7_16: J7.16 R91.2
NetJ7_18: J7.18 R93.2
NetJ7_20: J7.20 R90.2
NetTP29_1: TP29.1 U1.42(P3.0/TA1CLK/CBOUT)
NetTP30_1: TP30.1 U1.16(P5.6/ADC12CLK/DMAE0)
NetTP31_1: TP31.1 U1.88(P5.7/RTCCLK)
NetTP32_1: TP32.1 U1.19(P2.2/P2MAP2)
NetTP33_1: TP33.1 U1.20(P2.3/P2MAP3)
NetTP34_1: TP34.1 U1.21(P2.4/P2MAP4)

Not connected (* = marked no-connect by the designer): J7 11* 12*; U1 1(P6.4/CB4/A4)* 2(P6.5/CB5/A5)* 3(P6.6/CB6/A6/DAC0)* 4(P6.7/CB7/A7/DAC1)* 5(P7.4/CB8/A12)* 6(P7.5/CB9/A13)* 7(P7.6/CB10/A14/DAC0)* 8(P7.7/CB11/A15/DAC1)* 17(P2.0/P2MAP0)* 18(P2.1/P2MAP1)* 23(P2.6/P2MAP6)* 24(P2.7/P2MAP7)* 28(P5.2)* 30(DNC)* 31(P5.3) 32(P5.4) 33(P5.5) 38(P1.4/TA0.3)* 39(P1.5/TA0.4)* 40(P1.6/TA0.1)* 41(P1.7/TA0.2)* 48(P3.6/TA2.1)* 49(P3.7/TA2.2)* 58(P8.0/TB0CLK) 59(P8.1/UCB1STE/UCA1CLK) 68(P9.0)* 72(P9.4)* 73(P9.5)* 74(P9.6)* 75(P9.7)* 77(PU.0)* 78(NC)* 79(PU.1)* 80(LDOI)* 81(LDOO)* 82(NC)* 84(P7.2/XT2IN)* 85(P7.3/XT2OUT)* 86(VBAK)* 92(PJ.0/TDO)* 93(PJ.1/TDI/TCLK)* 94(PJ.2/TMS)* 95(PJ.3/TCK)* 98(P6.1/CB1/A1)* 99(P6.2/CB2/A2)* 100(P6.3/CB3/A3)*

### Notes on the sheet
- LEDS
- Main Signal Header
- RST/PUSH Button
- ID
- Device.
- The resistors on the ID[2:0] nets inform the firmware which device ID variant is on this board
- ID1
- Type
- ID3
- (near SH-J1) DEFAULT
- PINS 1-2
- DRV81008-Q1
- DRV81004-Q1
- Just In Case
- Revision 1
- Revision 2
- 0
- 1
- 2
- 3
- 4
- Prerelease
- Release
- (near S1) SELECT PUSH
- BUTTON FUNCT

### Library data of the parts
C15 C46 C50 C52-C54 = CMP-0006837-4: CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, 0603; Manufacturer: Wurth Elektronik; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 4.68; Value1: Unknown; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 1; SizeX_mm: 1.6; SizeY_mm: 0.8; SizeArea_mm2: 1.28; AEC Category: Q200
C41 C59 = CMP-0097311-1: 1000 pF ±5% 100V Ceramic Capacitor C0G, NP0 0603 (1608 Metric); Manufacturer: Wurth Electronics; TempCo: 30ppm/°C; SizeZ_mm: 0.87mm; AEC Qualified: No; Value: 1nF
C44 C45 = CMP-0006215-2: CAP, CERM, 10 pF, 50 V, +/- 5%, C0G/NP0, 0402; Manufacturer: Wurth Elektronik; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; Value1: Unknown; U/M: EA; Value: 10pF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; AEC Category: Q200
C49 = CMP-0097608-1: 0.47 µF ±10% 16V Ceramic Capacitor X7R 0603 (1608 Metric); Manufacturer: Wurth Electronics; AEC Qualified: No; Value: 470nF; TempCo: 15%; SizeZ_mm: 0.87mm
C51 = CMP-0097340-1: Alum. Polymer Cap 10µF 10V 5.5mmV-Chip WCAP-PSLP Series Lifetime 2000h +105°C; Manufacturer: Wurth Electronics; Life: 2000Hours; Dissipation Factor: 8%; Esr: 45m; IRMS_A: 1.2A; Tolerance_%: 20%; AEC Qualified: No; SizeZ_mm: 5.5mm; Leakage Current: 300uA
D3 = CMP-1426-00010-2: LED RED CLEAR 0805 SMD; Forward Voltage: 1.9V; Luminous Intensity: 60mcd; Dominant Wavelength: 630nm; Forward Current: 30mA; Viewing Angle: 140°; Lens Color: Colorless; Test Current: 20mA; Lens Size: 1.25mm
D5 D6 D8 D10-D19 = CMP-1426-00009-1: SMD mono-color Chip LED, WL-SMCW, Bright Green; Manufacturer: Wuerth Elektronik
J6 = CMP-0054796-4: Header, 2.54 mm, 3x1, Gold, TH; Manufacturer: Wurth Elektronik; Green_Lifecycle: Active; Green_REACh: Passed; CT: FALSE; CNHeader: TRUE
J7 = CMP-0054623-2: Header, 2.54mm, 10x2, Tin, TH; Manufacturer: Sullins Connector Solutions; Current_A: 3A; Green_Lifecycle: Not Set; Shrouded: N; Gender: Male; Green_REACh: Incomplete; Row_Count: 2; RowSpacing_mm: 2.54; Cert_UL: Y
R9 R37 = CMP-0097401-1: Thick Film Resistors 0402 10Ω ±1% 0.125W; Manufacturer: Wurth Electronics; TempCo: 100ppm/°C; VDC_V: 1.118V; Power_W: 125mW; AEC Qualified: No; SizeZ_mm: 0.4mm
R18 R19 = CMP-0026935-3: RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 200 ppm/C; Value_Code: 47k0; Value: 47k; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R30-R32 R39-R41 R51-R54 = CMP-0025886-5: RES, 10 k, 5%, 0.1 W, 0603; Manufacturer: Yageo; Power_W: 100mW; TempCo: 100 ppm/C; Value_Code: 10k0; Value: 10k; EIA_Code: E24; SizeX_mm: 1.6; SizeY_mm: 0.8; SizeZ_mm: 1; Value2: 0.1W; SizeArea_mm2: 1.28; AEC Qualified: N; VDC_V: 75V; AEC Category: Q200; SizeAreaWB_mm2: 4.68
R43 = CMP-0082533-1: RES, 4.99 k, 1%, 0.1 W, 0603; Manufacturer: Vishay-Dale; Value: 4.99k; Value_Code: 4k99; Power_W: 100mW; Value2: 0.1W; VDC_V: 75V; TempCo: 100 ppm/C; EIA_Code: E96; AEC Category: Q200; AEC Qualified: N; SizeAreaWB_mm2: 4.68; SizeX_mm: 1.6; SizeY_mm: 0.8; SizeZ_mm: 1; SizeArea_mm2: 1.28
R45 R47-R49 R80-R88 = CMP-0025785-4: RES, 330, 5%, 0.1 W, AEC-Q200 Grade 0, 0603; PartNumber: CRCW0603330RJNEA; Manufacturer: Vishay-Dale; Value: 330; Value_Code: 330R; Power_W: 100mW; Value2: 0.1W; VDC_V: 75V; TempCo: 200 ppm/C; EIA_Code: E24; AEC Category: Q200; AEC Qualified: Y; AEC Grade: 0; SizeX_mm: 1.6; SizeY_mm: 0.8; SizeZ_mm: 1; SizeArea_mm2: 1.28
R90-R93 R95 R96 = CMP-0026722-1: RES, 100, 1%, 0.063 W, 0402; Manufacturer: Yageo America; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 100R; U/M: EA; Value: 100; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: N; VDC_V: 50V; AEC Category: Q200
R94 = CMP-0026722-1: RES, 100, 1%, 0.063 W, 0402; Manufacturer: Yageo America; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 100R; U/M: EA; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: N; VDC_V: 50V; AEC Category: Q200
S1 = CMP-0097347-1: Tactile Switch SPST-NO Top Actuated Surface Mount; Manufacturer: Wurth Electronics; VDC_V: 12V; Electromechanical Life: 1000000Cycles; SizeZ_mm: 2.7mm; Coil Resistance_ohm: 100mΩ; Operating Force: 160gf; AEC Qualified: No; Contact Current Rating: 50mA
SH-J1 SH-J6-SH-J12 SH-J19 SH-J36 = CMP-0003761-2: Shunt, 2.54mm, Gold, Black; Manufacturer: Wurth Elektronik
TP19 TP29-TP34 = CMP-0003719-1: Testpoint; Manufacturer: Texas Instruments; CompType: Pad
TP20-TP28 = CMP-0055139-2: Test Point, Miniature, White, TH; Manufacturer: Keystone Electronics; ContactFinish: Silver; Green_REACh: Passed; CT: TRUE; Green_Lifecycle: Active; CNHeader: FALSE
TP35 = CMP-0055148-2: Test Point, Multipurpose, Black, TH; Manufacturer: Keystone Electronics; CNHeader: FALSE; Green_Lifecycle: Active; Green_REACh: Passed; ContactFinish: Silver; CT: TRUE
TP36 = CMP-0055140-2: Test Point, Miniature, Orange, TH; Manufacturer: Keystone Electronics; CNHeader: FALSE; Green_Lifecycle: Active; Green_REACh: Passed; ContactFinish: Silver; CT: TRUE
U1 = CMP-0038879-1: 20 MHz Mixed Signal Microcontroller with 256 KB Flash, 18432 B SRAM and 74 GPIOs, -40 to 85 degC, 100-pin QFP (PZ), Green (RoHS & no Sb/Br); Manufacturer: Texas Instruments; Flash(KB): 256; USCI_B (I2C & SPI): 2; ADC Channels: 16; Comparators: Yes; Frequency(MHz): 20; DMA: 3; SRAM(B): 18432; Multiplier: 32x32; GPIO: 74; Timers - 16-bit: 4; SubFamily: 5 Series; ADC: 12-bit SAR
Y2 = CMP-0004566-4: Crystal, 32.768 kHz, 12.5pF, SMD; Manufacturer: Micro Crystal AG; TaMin_C: -40°C; TaMax_C: 85°C; AEC Category: Q200; AEC Qualified: N; Frequency Tolerance: 20 ppm

## Nets that join several sheets
GND: OLD_MD081E1_DRV81xxx (57 pins), OLD_MD081E1_ezFET (45 pins), OLD_MD081E1_MCU (45 pins)
MCU_3V3: OLD_MD081E1_ezFET (J2.2 J10.10), OLD_MD081E1_MCU (21 pins)
VS: OLD_MD081E1_DRV81xxx (11 pins), OLD_MD081E1_MCU (D6.2)
IN0: OLD_MD081E1_DRV81xxx (U5.23), OLD_MD081E1_MCU (J7.5 TP22.1)
IN1: OLD_MD081E1_DRV81xxx (U5.22), OLD_MD081E1_MCU (J7.7 TP23.1)
MCU_UARTRXD: OLD_MD081E1_ezFET (J10.8), OLD_MD081E1_MCU (U1.61)
MCU_UARTTXD: OLD_MD081E1_ezFET (J10.6), OLD_MD081E1_MCU (U1.60)
nSCS: OLD_MD081E1_DRV81xxx (U5.1), OLD_MD081E1_MCU (J7.19 TP28.1)
nSLEEP: OLD_MD081E1_DRV81xxx (U5.21), OLD_MD081E1_MCU (J7.9 TP24.1)
RST/SBWTDIO: OLD_MD081E1_ezFET (J10.4), OLD_MD081E1_MCU (6 pins)
SCLK: OLD_MD081E1_DRV81xxx (U5.2), OLD_MD081E1_MCU (J7.17 TP27.1)
SDI: OLD_MD081E1_DRV81xxx (U5.3), OLD_MD081E1_MCU (J7.15 TP26.1)
SDO: OLD_MD081E1_DRV81xxx (U5.4), OLD_MD081E1_MCU (J7.13 TP25.1)
TST/SBWTCK: OLD_MD081E1_ezFET (J10.2), OLD_MD081E1_MCU (U1.91)
VBAT_MON: OLD_MD081E1_DRV81xxx (D20.1 R97.1 R98.2), OLD_MD081E1_MCU (U1.97)

## Assembly variants
001: not fitted FID1 FID2 FID3 LBL2 R31 R39 R40 R41 R54