# Altium PCB DRV81602Q1_EVM-042624.PcbDoc (part 4 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4575.07 x 3254.25 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 245 components, 136 nets, 685 pads, 291 vias.

## Via types
v1: diameter 24, hole 16, Top Layer to Bottom Layer, tented both sides, 184 vias
v2: diameter 24, hole 8, Top Layer to Bottom Layer, tented both sides, 61 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 21 vias
v4: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 16 vias
v5: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 9 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
SDO_MCU: R92.1 U1.66 | length 446.6
  Top Layer w8: U1.66@1029.29,2501.06 1075.18,2501.06 1090.93,2485.31 1207.01,2485.31 v5(1208.87,2487.18) ; v5(1391.44,2620) R92.1@1415,2620
  Bottom Layer w8: v5(1208.87,2487.18) 1341.7,2620 v5@1390,2620
T_RST_RST: R65.1 U2.43 | length 477.8
  Top Layer w10: U2.43@737.07,3765.87 737.35,3765.6 757.4,3765.6 758,3765 v1(785,3765) ; R65.1@750,3367.72 751.97,3367.72 767.32,3383.07 767.32,3387.32 v1(770,3390)
  Signal Layer 1 w10: v1(770,3390) 805,3425 805,3745 v1(785,3765)
T_TEST_TCKC: R64.1 U2.44 | length 569.4
  Top Layer w10: U2.44@737.07,3785.56 770.38,3785.56 774.7,3789.87 811.34,3789.87 816.21,3785 v1(820,3785) ; v1(945,3415) 947.68,3412.32 947.68,3393.07 970.16,3370.59 972.13,3370.59 R64.1@975,3367.72
  Signal Layer 1 w10: v1(820,3785) 945,3660 v1(945,3415)
TST/SBWTCK: J10.2 U1.91 | length 706.3
  Top Layer w10: v1(644.17,2794.45) 647.29,2794.45 665.76,2775.99 665.76,2746.48 U1.91@666.1,2746.13
  Signal Layer 1 w10: v1(945,2830) 1015,2900 1015,3054.02 J10.2@959.5,3109.52
  Signal Layer 2 w10: v1(644.17,2794.45) 909.45,2794.45 v1(945,2830)
USB_D_N: J11.2 R72.1 U6.3 | length 479.9
  Top Layer w8: J11.2@1197.41,4471.39 1197.41,4418.95 1218.06,4398.3 1218.06,4368.43 1193.51,4343.87 1186.91,4343.87 1185,4341.97 1185,4308.38 1184.84,4308.22 1184.84,4290.16 v1(1200,4275)
  Top Layer w15: R72.1@1150,4044.69 v1(1150,4095)
  Signal Layer 1 w15: v1(1150,4095) 1200,4145 v1(1200,4275)
USB_D_P: J11.3 R75.1 U6.2 U6.5 U6.6 | length 473.3
  Top Layer w8: U6.6@1145.63,4363.62 U6.5@1165.31,4363.62 ; v1(1150,4275) 1165.16,4290.16 1165.16,4316.38 1165.31,4316.54 U6.5@1165.31,4363.62 ; J11.3@1169.38,4469.57 1169.38,4408.97 1166.16,4405.75 1166.16,4364.47 U6.5@1165.31,4363.62
  Top Layer w15: R75.1@1200,4044.69 v1(1200,4095)
  Signal Layer 2 w15: v1(1150,4275) 1150,4145 v1(1200,4095)
VBAT_MON: D20.1 R97.1 R98.2 U1.97 | length 5691.3
  Top Layer w8: U1.97@547.99,2746.13 547.99,2562.01 685.25,2424.75 815.25,2424.75 v1(935,2305)
  Top Layer w10: D20.1@4500,3755.53 4527.56,3727.97 R98.2@4527.56,3680 R97.1@4527.56,3610 4525,3607.44 v2(4525,3560)
  Signal Layer 2 w8: v1(935,2305) 1078,2305 1271,2112 1971,2112 2060,2201 4081,2201 4311,2431 4311,2858 4525,3072 v2(4525,3560)
VDD: C9.1 R1.2 U5.24 | length 57.6
  Top Layer w8: U5.24@3410.75,3027.6 3456.93,3027.6 R1.2@3465,3019.53
VDD_3V3: C7.1 J1.2 R4.1
  other v2: 2543,3742 2577,3799
VM: C1.1 C2.1 C4.1 C8.2 C10.1 C14.1 C16.1 J4.1 J5.1 J12.2 J13.2 J14.2 J15.2 J18.1 J19.1 J20.2 J21.2 J24.1 J25.1 J26.2 J27.2 L3.2 TP4.1 TP6.1 TP41.1 U5.20 VM.1 | length 11225.7
  Top Layer w10: U5.20@3308.39,3025.83 3308.39,2981.61 v5(3310,2980)
  Bottom Layer w40: J26.2@1297,1584 1297,1580.76 1354.12,1523.65 1594.65,1523.65 1620,1549 ; J24.1@1620,1649 1620,1549 ; TP6.1@2461,4038 2250,4038 2208,4080 J20.2@2208,4194.34 2308,4294.34 J18.1@2308,4492 2411,4595 3076,4595 J25.1@3179,4492 3179,4294.34 J27.2@3079,4194.34 3219.34,4054 3753,4054 J15.2@3896,4197 3896,4292 J5.1@4096,4492 TP41.1@4341,4492 4341,4033 3744,3436 v2(3705,3436) ; J14.2@2629,1915 2529,1815 J4.1@2529,1649 ; TP4.1@3234,2096 3242.99,2087.01 3321.99,2087.01 J21.2@3494,1915 3494,1811 3446,1763 J19.1@3446,1649 ; VM.1@3819,3085 3979,3085 4135,2929 4321,2929 4418.52,2831.48 J12.2@4418.52,2707.48 4418.52,2700.86 4484.78,2634.6 4484.78,2273.14 4418.52,2206.88 J13.2@4418.52,2200.27 4262,2043.75 4262,1667 4144,1549 3546,1549 J19.1@3446,1649 ; 1620,1549 1644,1525 2405,1525 J4.1@2529,1649 ; J4.1@2529,1649 2637,1541 3338,1541 J19.1@3446,1649
  other v2: 3605,2936 3705,2936 3605,3036 3705,3036 3605,3136 3705,3136 3605,3236 3705,3236 3605,3336 3705,3336 3605,3436
VS: C3.1 C5.1 C6.1 C11.2 C12.1 C13.1 D6.2 F1.1 L3.1 R3.2 R97.2 TP40.1
  other v2: 3011,3751 2996,3807 3389,3858 3464,3858 3389,3958 3464,3958
pads on no net: FID1.1 FID2.1 FID3.1 J7.11 J7.12 J9.6 J9.10 J9.12 J9.13 J9.14 J10.11 J10.12 J11.4 LBL1.0 SH-J1.0 SH-J6.0 SH-J7.0 SH-J8.0 SH-J9.0 SH-J10.0 SH-J11.0 SH-J12.0 SH-J19.0 SH-J22.0 SH-J23.0 SH-J24.0 SH-J25.0 SH-J26.0 SH-J27.0 SH-J28.0 SH-J29.0 SH-J31.0 SH-J32.0 SH-J33.0 SH-J34.0 SH-J35.0 SH-J36.0 U1.1 U1.2 U1.3 U1.4 U1.5 U1.6 U1.7 U1.8 U1.17 U1.18 U1.22 U1.23 U1.24 U1.28 U1.30 U1.31 U1.32 U1.33 U1.39 U1.40 U1.41 U1.48 U1.49 U1.58 U1.59 U1.68 U1.72 U1.73 U1.74 U1.75 U1.77 U1.78 U1.79 U1.80 U1.81 U1.82 U1.84 U1.85 U1.86 U1.92 U1.93 U1.94 U1.95 U1.98 U1.99 U1.100 U2.3 U2.4 U2.5 U2.6 U2.7 U2.8 U2.10 U2.12 U2.13 U2.18 U2.19 U2.22 U2.23 U2.24 U2.25 U2.26 U2.27 U2.28 U2.29 U2.30 U2.31 U2.32 U2.33 U2.34 U2.35 U2.36 U2.41 U2.42 U2.45 U2.46 U2.47 U2.48 U3.2 U3.6 U3.7

## Polygon pours and split planes (outlines as drawn)
GND on Bottom Layer "BOTTOM_LAYER_GND_P301" (solid, remove dead copper, pour order 301): 17.16,1448.82 4586.16,1448.82 4586.16,4687.82 17.16,4687.82
VM on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 300): 3882,2946 3882,3148 3742,3288 3742,3390 3783,3431 3869,3431 3881,3443 3883.28,3481.72 3869,3496 3611,3496 3564,3449 3564,3094 3523,3053 3302,3053 3295,3046 3295,2976 3302,2969 3496,2969 3549,2916 3852,2916
VDD_3V3 on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 297): 2439,3914 2439,2741 2661,2519 3470,2519 3518,2567 3518,2756 3483,2791 2823,2791 2682,2932 2682,3921 2645,3958 2483,3958
VS on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 296): 3486,3993 3535,3944 3535,3775 3479,3720 2971.5,3720 2908.5,3783 2908.5,3848 3053.5,3993
NetF1_2 on Bottom Layer "BOTTOM_LAYER_NETF1_2_P284" (solid, remove dead copper, pour order 284): 4009,3140.57 4009,3428 4034,3453 4517,3453 4550,3421 4550,3140 4549.43,3140.57
GND on Top Layer "TOP_LAYER_GND_P298" (solid, remove dead copper, pour order 298): 15.78,4675 4577,4675 4577,1438 8,1438
VS on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 292): 3364,3793 3364,3960 3419,4015 3727,4015 3837,4126 3924,4126 4109,3941 4109,3731 4178,3662 4482,3662 4497,3647 4497,3593 4491,3587 4038,3587 3841,3784 3373,3784
VM on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 291): 3300,3056 3299,3055 3299,2976 3303,2972 3303,2635 3342,2596 3810,2596 3866,2652 3866,2970 3959,3063 3959,3565 3905,3619 3602,3619 3553,3570 3553,2720 3531,2698 3412,2698 3348,2762 3348,2921 3317,2952 3317,3054 3315,3056 3314,3056
VS on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 295): 2947.67,3739.67 2947.67,3853.67 2983,3889 3170,3889 3208,3851 3208,3762 3171,3725 3005,3725.72 2961.61,3725.72
VDD_3V3 on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 294): 2544,3832 2532,3820 2532,3738 2547,3723 2619,3723 2628,3732 2628,3829 2625,3832
NetF1_2 on Top Layer "TOP_LAYER_NETF1_2_P288" (solid, remove dead copper, pour order 288): 4006.93,3466.93 4068.5,3528.5 4501.5,3528.5 4550,3480 4550,3140 4549.43,3140.57 4006.93,3140.57
GND on Signal Layer 1 "SIGNAL_LAYER_1_GND_P184" (solid, remove dead copper, pour order 184): 15.78,4675 4577,4675 4577,1438 8,1438
GND on Signal Layer 2 "SIGNAL_LAYER_2_GND_P275" (solid, remove dead copper, pour order 275): 17.16,1448.82 4586.16,1448.82 4586.16,4687.82 17.16,4687.82

## Keep-outs
Keep-Out Layer:
  text ".Layer_Name" at 577,-858.49 h55

## Other copper
Top Layer:
  region net VM: 3298,3055 3298,2974 3301,2971 3301,2883 3313,2871 3343,2871 3346,2874 3346,2921 3318,2949 3318,3054 3316,3056 3299,3056
  region net VDD: 3401,3055 3401,2996 3407,2990 3475,2990 3496,3011 3496,3083 3492,3087 3476,3087 3446,3057 3403,3057
  region net EZFET_USB_Shield: 961.64,4642.75 961.64,4423 1102.44,4423 1102.44,4505 1125.53,4505 1244.47,4505 1244.47,4428.31 1298.15,4428.31 1298.15,4429.8 1395.23,4429.8 1393.66,4642.75
  text ".Layer_Name" at 577,-858.49 h55
Signal Layer 1:
  text "Signal Layer 1" at 511,-856.01 h60
Signal Layer 2:
  text "Signal Layer 2" at 576,-862.01 h60
Bottom Layer:
  region net EZFET_USB_Shield: 1394.4,4425 950,4425 950,4649 1394.4,4649
  text ".Layer_Name" at 577,-858.49 h55

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  drawing of 232 lines, arcs and shapes, not listed
  text "For EZFET-LITE Flashing Only" at 198,4608 h25
  text "VM" at 4310,4575 h35
  text "OUT2_D" at 4279,4176.83 h35
  text "OUT2_S" at 3349,4071.83 h35
  text "OUT6_S" at 1812,3920.83 h35
  text "OUT6_D" at 2048,3920.83 h35
  text "OUT4_S" at 2680,3920.83 h35
  text "OUT4_D" at 2914,3920.83 h35
  text "VM" at 2429,3915 h35
  text "GND" at 1281,3818 h35
  text "VS" at 3260,3773 h35 r90
  text "GND" at 1911,3676 h60
  text "nSCS" at 2249,3624 h40
  text "RST" at 1272.52,3536.47 h60
  text "SCLK" at 2249,3499 h40
  text "DRV81602-Q1" at 3123.76,3394.54 h33
  text "SDI" at 2249,3369 h40
  text "GND" at 100,3250 h60
  text "NETF1_2" at 3715,3242.66 h40
  text "SDO" at 2249,3234 h40
  text "VM" at 3779,3164 h40
  text "PUSH" at 1118.91,3162.9 h25
  text "RST" at 1374.76,3160.38 h25
  text "nSLEEP" at 2249,3099 h40
  text "GND" at 2634,3045 h60 r90
  text "IN1" at 2249,2954 h40
  text "3V3" at 99.73,2922.14 h60
  text "GND" at 4222,2859 h40
  text "IN0" at 2249,2814 h40
  text "3V3" at 2249,2644 h40
  text "GND" at 2647,2517 h60
  text "GND" at 2249,2509 h40
  text "GND" at 4194,2438 h60 r90
  text "CHANNEL STATUS" at 1659,2393 h35
  text "DRV81602-Q1_EVM" at 2472,2309 h50
  text "OUT7_S" at 2276,2182.83 h35
  text "OUT5_D" at 2632,2182.83 h35
  text "OUT5_S" at 2860,2182.83 h35
  text "VM" at 3207,2180 h35
  text "OUT0_LS" at 4180.17,2173 h35 r90
  text "CH6" at 1656.61,2170.09 h20
  text "CH4" at 1798.42,2168.36 h20
  text "CH2" at 1932.79,2168.36 h20
  text "CH0" at 2073.42,2168.36 h20
  text "OUT3_D" at 3495,2163.83 h35
  text "OUT3_S" at 3760,2160.83 h35
  text "OUT1_LS" at 3985,2093.83 h35
  text "CH7" at 1658,1945 h20
  text "CH5" at 1799,1943 h20
  text "CH3" at 1934,1943 h20
  text "CH1" at 2066,1941 h20
  text "OUT7_D" at 1394,1890.83 h35
  text "GND" at 1677,1853 h60
  text "FAULT_STATUS" at 1310.34,1649 h40 r90
  text "MCU_3V3" at 313.34,1606 h40 r90
  text "MCU_STATUS" at 667.34,1599 h40 r90
  text "GUI_STATUS" at 981.34,1599 h40 r90
  text "DRV_STATUS" at 1158.34,1599 h40 r90
  text ".Layer_Name" at 577,-858.49 h55
Bottom Overlay:
  drawing of 2342 lines, arcs and shapes, not listed
  text "305-PD-24-0437" at 1779.44,2399 h150
  text "APR 2024" at 1502,2244 h150
  text ".Layer_Name" at 577,-858.49 h55
Top Paste:
  text ".Layer_Name" at 577,-858.49 h25
Bottom Paste:
  text ".Layer_Name" at 577,-858.49 h25
Top Solder:
  text ".Layer_Name" at 577,-858.49 h55
  text ".Layer_Name" at 577,-858.49 h55
Bottom Solder:
  text ".Layer_Name" at 577,-858.49 h55
Drill Guide:
  text ".Layer_Name" at 577,-858.49 h55
M1 Board Outline:
  the board outline again, w10
  text ".Layer_Name" at 577,-858.49 h55
M2 Board Dimensions:
  rectangle: 0,-275 125,-150
  rectangle: 125,-400 500,-275
  lines w7: 0,-275 1000,-275 ; 125,-400 125,-150 ; 250,-400 250,-150 ; 500,-400 500,-150 ; 750,-400 750,-150 ; 0,-400 1000,-400 1000,-150 0,-150 0,-400
  text ".Layer_Name" at 577,-858.49 h55
M3 3D STEP Top:
  text ".Layer_Name" at 577,-858.49 h25
M4 3D STEP Bottom:
  text ".Layer_Name" at 577,-858.49 h25
M5 Assembly Top:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 1153.5,-318.5 h25
  text "ASSEMBLY VARIANT:" at 1153,-434 h25
  text ".VariantName" at 2189,-434 h25
  text "PCB VIEWED FROM TOP SIDE" at -228.5,-655.67 h25
  text "BOARD #:" at 2248,-655.67 h25
  text ".PRJ_Number" at 2793.5,-655.67 h25
  text "REV:" at 3638,-655.67 h25
  text ".PCB_Rev" at 3929.5,-655.67 h25
  text "SVN REV:" at 4476,-655.67 h25
  text ".VersionControl_RevNumber" at 4982,-655.67 h25
  text "TID #:" at 2248,-859 h25
  text ".TID" at 2793.5,-859 h25
  text "PLOT NAME =" at -228.5,-1064.34 h25
  text ".plot_File_Name" at 577,-1064.34 h25
  text "GENERATED    :" at 2250,-1064.34 h25
  text ".Print_Date" at 3119.5,-1064.34 h25
  text ".Print_Time" at 3848.5,-1064.34 h25
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h25
M6 Assembly Bottom:
  lines w10: -292.5,-727.33 6309.5,-727.33 ; -290.5,-930.67 6309.5,-930.67 ; 1115.5,-1140.5 1115.5,-937.67 ; 1737.5,-727.33 1737.5,-524 ; 2577.5,-727.33 2577.5,-524 ; 3844.5,-1134 3844.5,-524 ; 4733.5,-1134 6309,-1134 6309,-524 -292.5,-524 -292.5,-1134 2304.5,-1134 6309.5,-1134 6309.5,-524
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 6102,-318 h25
  text ".VariantName" at 5058,-434 h25
  text "ASSEMBLY VARIANT:" at 6097,-434 h25
  text ".VersionControl_RevNumber" at 1035.5,-656.17 h25
  text "SVN REV:" at 1541.5,-656.17 h25
  text ".PCB_Rev" at 2088,-656.17 h25
  text "REV:" at 2379.5,-656.17 h25
  text ".PRJ_Number" at 3224,-656.17 h25
  text "BOARD #:" at 3769.5,-656.17 h25
  text "PCB VIEWED FROM BOTTOM SIDE" at 6246,-656.17 h25
  text ".TID" at 3224,-859.5 h25
  text "TID #:" at 3769.5,-859.5 h25
  text "TEXAS INSTRUMENTS" at 904.5,-1064.84 h25
  text ".Print_Time" at 2169,-1064.84 h25
  text ".Print_Date" at 2898,-1064.84 h25
  text "GENERATED    :" at 3767.5,-1064.84 h25
  text ".plot_File_Name" at 5440.5,-1064.84 h25
  text "PLOT NAME =" at 6246,-1064.84 h25
M9 Title Sheet:
  drawing of 57 lines, arcs and shapes, not listed
  text "1" at 739.84,8036.5 h25
  text "2" at 3235.5,8036.5 h25
  text "3" at 5724.84,8036.5 h25
  text "4" at 8231.51,8036.5 h25
  text "5" at 10730.5,8036.5 h25
  text "6" at 13235.5,8036.5 h25
  text "A" at -416.5,6893.5 h25
  text "A" at 14383.5,6893.5 h25
  text "B" at -416.5,4513.5 h25
  text "B" at 14383.5,4513.5 h55
  text "C" at -416.5,2138.5 h25
  text "C" at 14383.5,2138.5 h55
  text "PROJECT TITLE:" at 11343.5,277.5 h55
  text "DRV81602Q1_EVM" at 11393.5,144.17 h55
  text "DESIGNED FOR:" at 11343.5,-23.5 h55
  text ".PRJ_Customer" at 11393.5,-163.5 h55
  text "D" at -416.5,-231.5 h25
  text "D" at 14383.5,-231.5 h55
  text "FILE NAME:" at 11343.5,-323.5 h55
  text ".PCB_File_Name_No_Path" at 11393.5,-443.5 h55
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 6374,-605.34 h40
  text "ENGINEER:" at 11343.5,-613.5 h55
  text "LAYOUT BY:" at 12848.5,-613.5 h55
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 6329.01,-718 h40
  text ".PRJ_Engineer" at 11393.5,-768.49 h55
  text ".PCB_Layout" at 12899,-768.49 h55
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 6329.01,-830.67 h40
  text ".Layer_Name" at 577,-858.49 h55
  text "ALTIUM DESIGNER VERSION:" at 12848.5,-923.5 h55
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 6329.01,-943.33 h40
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 6374,-1056 h40
  text ".print_Scale" at 11393.5,-1056.83 h55
  text ".Application_BuildNumber" at 12899,-1056.83 h55
  text "1" at 739.84,-1263.5 h25
  text "2" at 3235.5,-1263.5 h25
  text "3" at 5724.84,-1263.5 h25
  text "4" at 8231.51,-1263.5 h25
  text "5" at 10730.5,-1263.5 h25
  text "6" at 13235.5,-1263.5 h55
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 12382.02,6356.17 h55
  text "MIN. TRACK WIDTH:" at 11737.46,6224.05 h55
  text "6" at 12833.7,6224.05 h55
  text "MIL" at 12988.46,6224.05 h55
  text "5" at 12832,6105 h55
  text "MIN. CLEARANCE:" at 11737.46,6099.92 h55
  text "MIL" at 12988.46,6099.92 h55
  text "MIN. VIA PAD SIZE:" at 11737.46,5975.8 h55
  text "16" at 12803.71,5975.8 h55
  text "MIL" at 12988.46,5975.8 h55
  text "0.05mm (2MIL)" at 12432.46,5845.9 h55
  text "MINIMUM ANNULAR RING" at 11408.23,5837.67 h55
  text "EXTERNAL" at 13140.46,5837.67 h55
  text "PER" at 11608.23,5727.55 h55
  text "IPC-D-275 CLASS 2 LEVEL C" at 11828.23,5727.54 h55
  text "MIL, HOLES" at 13316.46,5627.07 h55
  text "+/-" at 12924,5618.48 h55
  text "+/-" at 13778,5618.48 h55
  text "REGISTRATION TOLERANCES:" at 11408.23,5617.42 h55
  text "METAL" at 12608,5617.42 h55
  text "5" at 13184.2,5617.42 h55
  text "3" at 14017.2,5617.42 h55
  text "MIL" at 14133.46,5617.42 h55
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 11408.23,5519.1 h55
  text "+/-" at 13778,5516.23 h55
  text "3" at 14017.2,5515.17 h55
  text "MIL" at 14133.46,5515.17 h55
  text "MATERIAL:" at 11333.46,5377.52 h55
  text "FR-4 High Tg" at 12319.9,5249 h55
  text "X" at 12175.46,5241.01 h55
  text "FR-408" at 11754.46,5236.49 h55
  text "OTHER" at 13242.46,5236.49 h55
  text "62 MIL (1.6mm) +/-10%" at 12074.56,5093.46 h55
  text "X" at 11954.46,5091.01 h55
  text "THICKNESS:" at 11408.23,5085.24 h55
  text "OTHER" at 13359.46,5085.24 h55
  text "TOLERANCE:" at 11408.23,4946.92 h55
  text "X" at 12256.46,4946.92 h55
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4946.92 h55
  text "OTHER +/-" at 12434.46,4802.73 h55
  text "BOW & TWIST:" at 11408.23,4657.54 h55
  text "X" at 12256.46,4657.54 h55
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4657.54 h55
  text "OTHER +/-" at 12434.46,4510.85 h55
  text "DRILLING:" at 11333.46,4380.23 h55
  text "NC_DRILL FILES" at 13094.46,4275.04 h55
  text "REFERENCE:" at 11408.23,4271.1 h55
  text "X" at 12065.46,4271.01 h55
  text "AS SHOWN" at 12243.46,4271.1 h55
  text "X" at 12966.46,4271.1 h55
  text "OTHER" at 13392.46,4128.85 h55
  text "PTH COPPER THICKNESS:" at 11407.91,4125.32 h55
  text "X" at 12547.14,4125.32 h55
  text "20-30 um" at 12675.14,4125.32 h55
  text "BOARD FINISH:" at 11333.46,3977.73 h55
  text "SILKSCREEN:" at 11488.68,3867.6 h55
  text "X" at 12446.46,3867.6 h55
  text "TOP" at 12563.46,3867.6 h55
  text "X" at 12956.46,3867.6 h55
  text "BOTTOM" at 13074.46,3867.6 h55
  text "SILKSCREEN COLOR:" at 11488.68,3712.41 h55
  text "X" at 12445.46,3712.41 h55
  text "WHITE" at 12563.46,3712.41 h55
  text "OTHER" at 13074.46,3712.41 h55
  text "X" at 12576.46,3568.96 h55
  text "GREEN" at 12694.46,3568.96 h55
  text "OTHER" at 13312.46,3568.96 h55
  text "SOLDER RESIST COLOR:" at 11488.68,3562.1 h55
  text "X" at 12576.46,3414.71 h55
  text "MATTE" at 12694.46,3414.71 h55
  text "SEMI-GLOSS" at 13312,3414.07 h55
  text "IMMERSION GOLD (ENIG)" at 12394.46,3241.94 h55
  text "ENEPIG" at 13732,3234.72 h55
  text "SURFACE FINISH:" at 11333.46,3233.72 h55
  text "X" at 12216.46,3233.72 h55
  text "IMM. TIN/SILVER OR EQUIV" at 11663,3096.4 h55
  text "OTHER" at 13094.46,3092.47 h55
  text "ARRAY/PANEL:" at 11333.46,2937.09 h55
  text "X" at 12216.46,2932.9 h55
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 12394.46,2928.87 h55
  text "N.C. ROUTE" at 12394.46,2792.9 h55
  text "V. SCORE" at 13260.46,2792.9 h55
  text "CERTIFICATION:" at 11333.46,2663.77 h55
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 12058.46,2663.77 h55
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 12058.46,2569.71 h55
  text "X" at 11695.97,2441.08 h55
  text "ANSI IPC-A-600F CLASS ->" at 11823.96,2441.08 h55
  text "X" at 13471.97,2441.08 h55
  text "2" at 13581.96,2441.08 h55
  text "1" at 13266.96,2439.58 h55
  text "3" at 13935.96,2439.58 h55
  text "X" at 12507.97,2293.39 h55
  text "RoHS" at 12635.96,2293.39 h55
  text "OTHER" at 13280.36,2293.39 h55
  text "PER ORDER" at 13677.42,2293.39 h55
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 11361,2139.57 h55
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 11361,2023.5 h55
  text "FAB NOTES:" at 5661.93,1902.41 h55
  text "ADDITIONAL REQUIREMENTS:" at 11333.46,1854.08 h55
  text "1. NO VENDOR LOGO OR NAME ON THE BOARD." at 5660.93,1775.72 h55
  text "MICROSECTION:" at 11408.23,1746.95 h55
  text "YES" at 12313.96,1746.95 h55
  text "2. ALL HOLES SHOULD BE FHS." at 5660.93,1653.09 h55
  text "REQUIRED" at 13175.46,1602.62 h55
  text "BARE BOARD ELEC. TEST:" at 11408.23,1599.76 h55
  text "NONE" at 12713.96,1599.76 h55
  text "X" at 13057.46,1599.76 h55
  text "PER ORDER" at 13767.46,1599.76 h55
  text "3. CLIP SILK ON NO MASK AREA." at 5664.93,1532.89 h55
  text "4. 7.87MIL DRILLS NEED TO BE NON-CONDUCTIVE SOLDER MASK PLUGGING FROM BOTTOM SIDE" at 5663,1445 h55
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 11576.38,1394.82 h55
  text "5.REMOVE NON-FUNCTINAL PADS IN INNER LAYER ." at 5666,1349 h55
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 11584.38,1290.84 h55
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 11583.39,1127.46 h55
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 11575.39,891.74 h55
  text ".Layer_Name" at 577,-858.49 h55
M11 Gerber Information:
  circle w10: c-154,4801 r40
  circle w10: c-154,4801 r70
  circle w10: c4807,4743 r40
  circle w10: c4807,4743 r70
  circle w10: c4716,1328 r40
  circle w10: c4716,1328 r70
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; -254,4801 -54,4801 ; -154,4701 -154,4901 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4616,1328 4816,1328 ; 4707,4743 4907,4743 ; 4716,1228 4716,1428 ; 4807,4643 4807,4843 ; 4902,-1140 4902,-937.17
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -228.5,-655.67 h55
  text "BOARD #:" at 2248,-655.67 h55
  text "REV:" at 3638,-655.67 h55
  text ".PCB_Rev" at 3929.5,-655.67 h55
  text "SVN REV:" at 4476,-655.67 h55
  text ".VersionControl_RevNumber" at 4982,-655.67 h55
  text "DRV81602Q1_EVM" at 2674,-667 h55
  text "LAYER NAME =" at -228.5,-858.49 h55
  text "TID #:" at 2248,-859 h55
  text ".TID" at 2793.5,-859 h55
  text "PLOT NAME =" at -228.5,-1064.34 h55
  text ".plot_File_Name" at 577,-1064.34 h35
  text "GENERATED    :" at 2250,-1064.34 h55
  text ".Print_Date" at 3119.5,-1064.34 h55
  text ".Print_Time" at 3848.5,-1064.34 h55
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h55
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Stackup;" at 5703,5083.99 h60
  text "Layer" at 5743.98,4967.59 h51.05
  text "Name" at 6095.76,4967.59 h51.05
  text "Material" at 6898.37,4967.59 h51.05
  text "Thickness" at 7632.93,4967.59 h51.05
  text "Constant" at 8188.86,4967.59 h51.05
  text "Board Layer Stack" at 8676.74,4967.59 h51.05
  text "Top Overlay" at 6095.76,4865.48 h51.05
  text "Top Solder" at 6095.76,4763.37 h51.05
  text "Solder Resist" at 6898.37,4763.37 h51.05
  text "0.40mil" at 7632.93,4763.37 h51.05
  text "3.5" at 8188.86,4763.37 h51.05
  text "1" at 5743.98,4661.26 h51.05
  text "Top Layer" at 6095.76,4661.26 h51.05
  text "2.80mil" at 7632.93,4661.26 h51.05
  text "Dielectric 1" at 6095.76,4559.15 h51.05
  text "FR-4 High Tg" at 6898.37,4559.15 h51.05
  text "11.40mil" at 7632.93,4559.15 h51.05
  text "4.2" at 8188.86,4559.15 h51.05
  text "2" at 5743.98,4457.05 h51.05
  text "Signal Layer 1" at 6095.76,4457.05 h51.05
  text "1.40mil" at 7632.93,4457.05 h51.05
  text "Dielectric 2" at 6095.76,4354.94 h51.05
  text "FR-4 High Tg" at 6898.37,4354.94 h51.05
  text "30.00mil" at 7632.93,4354.94 h51.05
  text "4.2" at 8188.86,4354.94 h51.05
  text "3" at 5743.98,4252.83 h51.05
  text "Signal Layer 2" at 6095.76,4252.83 h51.05
  text "1.40mil" at 7632.93,4252.83 h51.05
  text "Dielectric 3" at 6095.76,4150.72 h51.05
  text "FR-4 High Tg" at 6898.37,4150.72 h51.05
  text "11.40mil" at 7632.93,4150.72 h51.05
  text "4.2" at 8188.86,4150.72 h51.05
  text "4" at 5743.98,4048.61 h51.05
  text "Bottom Layer" at 6095.76,4048.61 h51.05
  text "2.80mil" at 7632.93,4048.61 h51.05
  text "Bottom Solder" at 6095.76,3946.5 h51.05
  text "Solder Resist" at 6898.37,3946.5 h51.05
  text "0.40mil" at 7632.93,3946.5 h51.05
  text "3.5" at 8188.86,3946.5 h51.05
  text "Bottom Overlay" at 6095.76,3844.39 h51.05
  text ".Layer_Name" at 577,-858.49 h55
M13 Component Bodies Top:
  text ".Layer_Name" at 577,-858.49 h25
M14 Component Bodies Bottom:
  text ".Layer_Name" at 577,-858.49 h25
M15 Courtyards Top:
  text ".Layer_Name" at 577,-858.49 h25
M16 Courtyards Bottom:
  text ".Layer_Name" at 577,-858.49 h25
Drill Drawing:
  circle w8: c5464.85,3434.82 r12.69
  circle w8: c5464.85,3434.82 r21.15
  circle w8: c5464.85,2673.51 r21.15
  lines w8: 5443.7,2271.71 5486,2271.71 5486,2314 5443.7,2314 5443.7,2271.71 ; 5443.7,2366.87 5486,2366.87 5486,2409.17 5443.7,2409.17 5443.7,2366.87 ; 5443.7,2472.61 5454.28,2472.61 5464.85,2462.03 5475.43,2472.61 5486,2472.61 5475.43,2483.18 5486,2493.76 5475.43,2493.76 5464.85,2504.33 5454.28,2493.76 5443.7,2493.76 5454.28,2483.18 5443.7,2472.61 ; 5443.7,2557.2 5464.85,2567.77 5486,2557.2 5475.43,2578.35 5486,2599.49 5464.85,2588.92 5443.7,2599.49 5454.28,2578.35 5443.7,2557.2 ; 5443.7,2789.82 5486,2789.82 5464.85,2747.52 5443.7,2789.82 ; 5443.7,2853.26 5454.28,2853.26 5454.28,2842.69 5475.43,2842.69 5475.43,2853.26 5486,2853.26 5486,2874.41 5475.43,2874.41 5475.43,2884.98 5454.28,2884.98 5454.28,2874.41 5443.7,2874.41 5443.7,2853.26 ; 5443.7,2959 5464.85,2937.85 5486,2959 5464.85,2980.15 5443.7,2959 ; 5443.7,3033.02 5464.85,3043.59 5486,3033.02 5475.43,3054.16 5486,3075.31 5464.85,3064.74 5443.7,3075.31 5454.28,3054.16 5443.7,3033.02 ; 5443.7,3128.18 5443.7,3138.75 5454.28,3149.33 5443.7,3159.9 5443.7,3170.47 5454.28,3170.47 5464.85,3159.9 5475.43,3170.47 5486,3170.47 5486,3159.9 5475.43,3149.33 5486,3138.75 5486,3128.18 5475.43,3128.18 5464.85,3138.75 5454.28,3128.18 5443.7,3128.18 ; 5443.7,3233.92 5454.28,3233.92 5464.85,3223.34 5475.43,3233.92 5486,3233.92 5475.43,3244.49 5486,3255.06 5475.43,3255.06 5464.85,3265.64 5454.28,3255.06 5443.7,3255.06 5454.28,3244.49 5443.7,3233.92 ; 5443.7,3329.08 5454.28,3329.08 5454.28,3318.51 5475.43,3318.51 5475.43,3329.08 5486,3329.08 5486,3350.23 5475.43,3350.23 5475.43,3360.8 5454.28,3360.8 5454.28,3350.23 5443.7,3350.23 5443.7,3329.08 ; 5452.16,2375.33 5477.54,2375.33 5477.54,2400.71 5452.16,2400.71 5452.16,2375.33 ; 5452.16,2565.66 5464.85,2572 5477.54,2565.66 5471.2,2578.35 5477.54,2591.03 5464.85,2584.69 5452.16,2591.03 5458.51,2578.35 5452.16,2565.66 ; 5452.16,2857.49 5458.51,2857.49 5458.51,2851.15 5471.2,2851.15 5471.2,2857.49 5477.54,2857.49 5477.54,2870.18 5471.2,2870.18 5471.2,2876.52 5458.51,2876.52 5458.51,2870.18 5452.16,2870.18 5452.16,2857.49 ; 5452.16,3238.15 5458.51,3238.15 5464.85,3231.8 5471.2,3238.15 5477.54,3238.15 5471.2,3244.49 5477.54,3250.84 5471.2,3250.84 5464.85,3257.18 5458.51,3250.84 5452.16,3250.84 5458.51,3244.49 5452.16,3238.15
  lines w12: 5405.25,2243.16 11068.39,2243.16 ; 5405.25,3480.29 11068.39,3480.29 ; 5760.04,2147.99 5760.04,3575.45 ; 6170,2147.99 6170,3575.45 ; 7028.98,2147.99 7028.98,3575.45 ; 7355.22,2147.99 7355.22,3575.45 ; 7826.06,2147.99 7826.06,3575.45 ; 8780.72,2147.99 8780.72,3575.45 ; 9472.27,2147.99 9472.27,3575.45 ; 10338.87,2147.99 10338.87,3575.45 ; 5405.25,2147.99 11068.39,2147.99 11068.39,3575.45 5405.25,3575.45 5405.25,2147.99
  text "Drill Drawing :" at 5420,3619.99 h60
  text "Symbol" at 5462.35,3508.83 h45.68
  text "Quantity" at 5788.59,3508.83 h45.68
  text "Finished Hole Size" at 6198.55,3508.83 h45.68
  text "Plated" at 7057.53,3508.83 h45.68
  text "Hole Type" at 7383.77,3508.83 h45.68
  text "Drill Layer Pair" at 7854.61,3508.83 h45.68
  text "Hole Tolerance" at 8809.27,3508.83 h45.68
  text "Routed Path Length" at 9500.82,3508.83 h45.68
  text "Hole Length" at 10367.42,3508.83 h45.68
  text "37" at 5788.59,3413.67 h38.07
  text "7.87mil (0.200mm)" at 6198.55,3413.67 h38.07
  text "PTH" at 7057.53,3413.67 h38.07
  text "Round" at 7383.77,3413.67 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,3413.67 h38.07
  text "+3mil/-3mil" at 8809.27,3413.67 h38.07
  text "-" at 9500.82,3413.67 h38.07
  text "-" at 10367.42,3413.67 h38.07
  text "61" at 5788.59,3318.51 h38.07
  text "8.00mil (0.203mm)" at 6198.55,3318.51 h38.07
  text "PTH" at 7057.53,3318.51 h38.07
  text "Round" at 7383.77,3318.51 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,3318.51 h38.07
  text "+3mil/-3mil" at 8809.27,3318.51 h38.07
  text "-" at 9500.82,3318.51 h38.07
  text "-" at 10367.42,3318.51 h38.07
  text "9" at 5788.59,3223.34 h38.07
  text "10.00mil (0.254mm)" at 6198.55,3223.34 h38.07
  text "PTH" at 7057.53,3223.34 h38.07
  text "Round" at 7383.77,3223.34 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,3223.34 h38.07
  text "+3mil/-3mil" at 8809.27,3223.34 h38.07
  text "-" at 9500.82,3223.34 h38.07
  text "-" at 10367.42,3223.34 h38.07
  text "184" at 5788.59,3128.18 h38.07
  text "16.00mil (0.406mm)" at 6198.55,3128.18 h38.07
  text "PTH" at 7057.53,3128.18 h38.07
  text "Round" at 7383.77,3128.18 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,3128.18 h38.07
  text "+3mil/-3mil" at 8809.27,3128.18 h38.07
  text "-" at 9500.82,3128.18 h38.07
  text "-" at 10367.42,3128.18 h38.07
  text "7" at 5788.59,3033.02 h38.07
  text "17.72mil (0.450mm)" at 6198.55,3033.02 h38.07
  text "PTH" at 7057.53,3033.02 h38.07
  text "Round" at 7383.77,3033.02 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,3033.02 h38.07
  text "+3mil/-3mil" at 8809.27,3033.02 h38.07
  text "-" at 9500.82,3033.02 h38.07
  text "-" at 10367.42,3033.02 h38.07
  text "58" at 5788.59,2937.85 h38.07
  text "40.00mil (1.016mm)" at 6198.55,2937.85 h38.07
  text "PTH" at 7057.53,2937.85 h38.07
  text "Round" at 7383.77,2937.85 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,2937.85 h38.07
  text "+3mil/-3mil" at 8809.27,2937.85 h38.07
  text "-" at 9500.82,2937.85 h38.07
  text "-" at 10367.42,2937.85 h38.07
  text "28" at 5788.59,2842.69 h38.07
  text "43.31mil (1.100mm)" at 6198.55,2842.69 h38.07
  text "PTH" at 7057.53,2842.69 h38.07
  text "Round" at 7383.77,2842.69 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,2842.69 h38.07
  text "+3mil/-3mil" at 8809.27,2842.69 h38.07
  text "-" at 9500.82,2842.69 h38.07
  text "-" at 10367.42,2842.69 h38.07
  text "3" at 5788.59,2747.52 h38.07
  text "45.28mil (1.150mm)" at 6198.55,2747.52 h38.07
  text "PTH" at 7057.53,2747.52 h38.07
  text "Round" at 7383.77,2747.52 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,2747.52 h38.07
  text "+3mil/-3mil" at 8809.27,2747.52 h38.07
  text "-" at 9500.82,2747.52 h38.07
  text "-" at 10367.42,2747.52 h38.07
  text "34" at 5788.59,2652.36 h38.07
  text "51.18mil (1.300mm)" at 6198.55,2652.36 h38.07
  text "PTH" at 7057.53,2652.36 h38.07
  text "Round" at 7383.77,2652.36 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,2652.36 h38.07
  text "+3mil/-3mil" at 8809.27,2652.36 h38.07
  text "-" at 9500.82,2652.36 h38.07
  text "-" at 10367.42,2652.36 h38.07
  text "2" at 5788.59,2557.2 h38.07
  text "59.06mil (1.500mm)" at 6198.55,2557.2 h38.07
  text "PTH" at 7057.53,2557.2 h38.07
  text "Round" at 7383.77,2557.2 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,2557.2 h38.07
  text "+3mil/-3mil" at 8809.27,2557.2 h38.07
  text "-" at 9500.82,2557.2 h38.07
  text "-" at 10367.42,2557.2 h38.07
  text "22" at 5788.59,2462.03 h38.07
  text "63.00mil (1.600mm)" at 6198.55,2462.03 h38.07
  text "PTH" at 7057.53,2462.03 h38.07
  text "Round" at 7383.77,2462.03 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,2462.03 h38.07
  text "+3mil/-3mil" at 8809.27,2462.03 h38.07
  text "-" at 9500.82,2462.03 h38.07
  text "-" at 10367.42,2462.03 h38.07
  text "2" at 5788.59,2366.87 h38.07
  text "25.59mil (0.650mm)" at 6198.55,2366.87 h38.07
  text "PTH" at 7057.53,2366.87 h38.07
  text "Slot" at 7383.77,2366.87 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,2366.87 h38.07
  text "+3mil/-3mil" at 8809.27,2366.87 h38.07
  text "3.94mil (0.100mm)" at 9500.82,2366.87 h38.07
  text "29.53mil (0.750mm)" at 10367.42,2366.87 h38.07
  text "2" at 5788.59,2271.71 h38.07
  text "51.18mil (1.300mm)" at 6198.55,2271.71 h38.07
  text "PTH" at 7057.53,2271.71 h38.07
  text "Slot" at 7383.77,2271.71 h38.07
  text "Top Layer - Bottom Layer" at 7854.61,2271.71 h38.07
  text "+3mil/-3mil" at 8809.27,2271.71 h38.07
  text "-21.65mil (-0.550mm)" at 9500.82,2271.71 h38.07
  text "29.53mil (0.750mm)" at 10367.42,2271.71 h38.07
  text "449 Total" at 5788.59,2176.54 h38.07
  text "Slot definitions :" at 5462.35,2081.26 h38.07
  text "Routed Path Length" at 6122.15,2081.26 h38.07
  text "= Calculated from tool start centre position to tool end centre position." at 6826.35,2081.26 h38.07
  text "Hole Length" at 6122.15,2014.52 h38.07
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 6566.32,2014.52 h38.07
  text ".Layer_Name" at 577,-858.49 h55
Mechanical 17:
  text ".Layer_Name" at 577,-858.49 h55
Mechanical 18:
  text ".Layer_Name" at 577,-858.49 h55
Mechanical 19:
  text ".Layer_Name" at 577,-858.49 h55

## Dimensions
0,-400 to 1000,-400 on M2 Board Dimensions
7.08,4684 to 2,1434 on M2 Board Dimensions
7.08,4684 to 4577.07,4688.25 on M2 Board Dimensions