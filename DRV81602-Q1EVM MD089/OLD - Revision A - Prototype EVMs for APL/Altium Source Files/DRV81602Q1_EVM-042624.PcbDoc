# Altium PCB DRV81602Q1_EVM-042624.PcbDoc (part 3 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4575.07 x 3254.25 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 245 components, 136 nets, 685 pads, 291 vias.

## Part data (continued)
R1: library part CMP-0095262-1, "100 Ohms ±5% 0.2W, 1/5W Chip Resistor 0603 (1608 Metric) Automotive AEC-Q200, Moisture Resistant, Pulse Withstanding Thick Film", Digikey Part Number=2019-SG73S1JTTD101JCT-ND, Manufacturer="KOA Speer", Mouser Part Number=660-SG73S1JTTD101J, Operating Temperature Range="-55°C to +155°C", Power_W=200mW, TempCo=100ppm/°C, Tolerance_%=5%
R3 R4 R62 R63 R68: library part CMP-0025697-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, PartNumber=CRCW06030000Z0EA, Power_W=100mW, Supplier Part Number 1=541-0.0GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000, ValueDisplayed=0
R9 R37 R64 R65 R66 R67: library part CMP-0097401-1, "Thick Film Resistors 0402 10Ω ±1% 0.125W", Manufacturer="Wurth Electronics", Operating Temperature Range="-55°C to +155°C", Power_W=125mW, TempCo=100ppm/°C, Tolerance_%=1%
R18 R19 R57: library part CMP-0026935-3, "RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-47KJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=47k0, ValueDisplayed=47k
R30 R31 R32 R39 R40 R41 R51 R52 R53 R54: library part CMP-0025886-5, "RES, 10 k, 5%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-10KGRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10k
R43: library part CMP-0082533-1, "RES, 4.99 k, 1%, 0.1 W, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-3985-1-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=4k99, ValueDisplayed=4.99k
R45 R47 R48 R49 R80 R81 R82 R83 R84 R85 R86 R87 R88: library part CMP-0025785-4, "RES, 330, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, PartNumber=CRCW0603330RJNEA, Power_W=100mW, Supplier Part Number 1=541-330GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=330R, ValueDisplayed=330
R55 R60: library part CMP-0026728-1, "RES, 220 k, 1%, 0.0625 W, 0402", Manufacturer="Yageo America", Power_W=62.5mW, Supplier Part Number 1=311-220KLRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.0625W, Value_Code=220k
R56: library part CMP-0026190-2, "RES, 240 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-240KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=240k
R58: library part CMP-0025924-5, "RES, 470, 5%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-470GRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=470R, ValueDisplayed=470
R59: library part CMP-0025930-5, "RES, 560, 5%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-560GRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=560R, ValueDisplayed=560
R61: library part CMP-0026021-3, "RES, 150 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-150KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=150k
R72 R75: library part CMP-0026888-3, "RES, 27, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-27JCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=27R0, ValueDisplayed=27
R76: library part CMP-0026085-3, "RES, 1.40 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.40KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=1k40, ValueDisplayed=1.40k
R77: library part CMP-0026859-2, "RES, 1.0 M, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.0MJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=1M00, ValueDisplayed=1.0M
R78: library part CMP-0026907-3, "RES, 33 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-33KJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=33k0, ValueDisplayed=33k
R90 R91 R92 R93 R94 R95: library part CMP-0026722-1, "RES, 100, 1%, 0.063 W, 0402", Manufacturer="Yageo America", Power_W=63mW, Supplier Part Number 1=311-100LRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=100R, ValueDisplayed=100
R96: library part CMP-0026722-1, "RES, 100, 1%, 0.063 W, 0402", Manufacturer="Yageo America", Power_W=63mW, Supplier Part Number 1=311-100LRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=100R
R97: library part CMP-0023620-3, "RES, 91.0 k, 0.1%, 0.1 W, 0603", Manufacturer="Susumu Co Ltd", Power_W=100mW, Supplier Part Number 1=RG16P91.0KBCT-ND, TempCo="25 ppm/C", Tolerance_%=0.1%, Value2=0.1W, Value_Code=91k0, ValueDisplayed=91.0k
R98: library part CMP-0023404-3, "RES, 10.0 k, 0.1%, 0.1 W, 0603", Manufacturer="Susumu Co Ltd", Power_W=100mW, Supplier Part Number 1=RG16P10.0KBCT-ND, TempCo="25 ppm/C", Tolerance_%=0.1%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10.0k
S1: library part CMP-0097347-1, "Tactile Switch SPST-NO Top Actuated Surface Mount", Coil Resistance_ohm=100mΩ, Contact Current Rating=50mA, Digikey Part Number=732-7022-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-430481025816, Operating Force=160gf, Operating Temperature Range="-40°C to +85°C"
SH-J1 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J31 SH-J32 SH-J33 SH-J34 SH-J35 SH-J36: library part CMP-0003761-2, "Shunt, 2.54mm, Gold, Black", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-2678-ND
TP1 TP35: library part CMP-0055148-2, "Test Point, Multipurpose, Black, TH", Color=Black, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5011-ND
TP2 TP4 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 VM: library part CMP-0055147-2, "Test Point, Multipurpose, Red, TH", Color=Red, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5010-ND
TP3 TP5: library part CMP-0055149-2, "Test Point, Multipurpose, White, TH", Color=White, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5012-ND
TP19 TP29 TP30 TP31 TP32 TP33 TP34: library part CMP-0003719-1, "Testpoint", Manufacturer="Texas Instruments"
TP20 TP21 TP22 TP23 TP24 TP25 TP26 TP27 TP28: library part CMP-0055139-2, "Test Point, Miniature, White, TH", Color=White, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5002-ND
TP36: library part CMP-0055140-2, "Test Point, Miniature, Orange, TH", Color=Orange, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5003-ND
TP37 TP38 TP39: library part CMP-0075110-1, "1mm Uninsulated Shorting Plug, 10.16mm spacing, TH", Manufacturer=Harwin, PartNumber=D3082-05, Supplier Part Number 1=952-1873-ND
TP40 TP41: library part CMP-0055147-1, "Test Point, Multipurpose, Red, TH", Color=Red, Manufacturer=Keystone, Supplier Part Number 1=36-5010-ND
U1: library part CMP-0038879-1, "20 MHz Mixed Signal Microcontroller with 256 KB Flash, 18432 B SRAM and 74 GPIOs, -40 to 85 degC, 100-pin QFP (PZ), Green (RoHS & no Sb/Br)", Frequency(MHz)=20, Manufacturer="Texas Instruments", Temp Sensor=Yes
U2: library part CMP-0039269-4, "16-Bit Ultra-Low-Power Microcontroller, 128KB Flash, 8KB RAM, USB, 12Bit ADC, 2 USCIs, 32Bit HW MPY, RGC0064B (VQFN-64)", Alternate Manufacturer="Texas Instruments", Alternate PartNumber=MSP430F5528IRGCR, Frequency(MHz)=25, Operating Temperature Range="-40 to 85 C", Rating=Catalog, Temp Sensor=Yes
U3: library part CMP-0036328-3, "500mA, Adjustable, Low Quiescent Current, Low-Noise, High-PSRR, Single-Output LDO Regulator, DRB0008A (VSON-8)", Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 125 C", Rating=Catalog
U4: library part CMP-0070570-1, "Ultra-Low Quiescent Current Voltage Regulator, 8-pin Narrow SOIC, Pb-Free", Manufacturer="Texas Instruments", PackageTopMarking=NSZXTT*LM903*6M-3, PowerWise=N
U5: library part CMP-0120420-1, "8-channel Configurable Low-side and High-side Driver for Automotive Relay, Lighting and Motor Control", Manufacturer="Texas Instruments", Max Supply Voltage=40V, Min Supply Voltage=3V, Operating Temperature Range="-40°C to +125°C"
U6: library part CMP-0043099-3, "Low-Capacitance 2-Channel +/-15kV ESD Protection Array for High-Speed Data Interfaces, DRY0006A (USON-6)", Breakdown Voltage(Min)(V)=11, IO Capacitance(Typ)(pF)=1.5, IO Leakage Current(nA)=1, Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 85 C", Rating=Catalog
Y1: library part CMP-0085483-1, "Oscillator, 4 MHz, 700 ppm, 39 pF, SMD", Frequency_Fixed=4MHz, Frequency Tolerance="700 ppm", Load Capacitance="39 pF", Manufacturer=MuRata
Y2: library part CMP-0004566-4, "Crystal, 32.768 kHz, 12.5pF, SMD", Frequency Tolerance="20 ppm", Frequency_Fixed=32.768kHz, Load Capacitance="12.5 pF", Manufacturer="Micro Crystal AG", Supplier Part Number 1=94M8466

## Via types
v1: diameter 24, hole 16, Top Layer to Bottom Layer, tented both sides, 184 vias
v2: diameter 24, hole 8, Top Layer to Bottom Layer, tented both sides, 61 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 21 vias
v4: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 16 vias
v5: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 9 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
CHANNEL_0: D15.2 U1.50 | length 1509.6
  Top Layer w8: v1@961.38,2085.06 U1.50@961.38,2137.87 ; D15.2@2095,2315.12 2159.59,2315.12 v1(2160.61,2314.09)
  Bottom Layer w8: v1(961.7,2084.73) 1307.97,2431 2043.7,2431 v1(2160.61,2314.09)
CHANNEL_1: D19.2 U1.51 | length 1330.4
  Top Layer w8: U1.51@1029.29,2205.78 1249.54,2205.78 v1(1280,2175.32) ; v1(2095,2000) 2091.1,2037.97 D19.2@2095,2042.76
  Bottom Layer w8: v1(1280,2175.32) 1311.41,2143.91 1510.09,2143.91 1582,2072 1582,1987 1672,1897 1992,1897 v1(2095,2000)
CHANNEL_2: D14.2 U1.52 | length 1171.2
  Top Layer w8: U1.52@1029.29,2225.46 1294.85,2225.46 v1(1325,2195.32) ; D14.2@1955,2315.12 1956.02,2314.09 v1(2025.61,2314.09)
  Signal Layer 2 w8: v1(1325,2195.32) 1358.68,2229 1727,2229 1863,2365 1974.7,2365 v1(2025.61,2314.09)
CHANNEL_3: D18.2 U1.53 | length 1208.7
  Top Layer w8: U1.53@1029.29,2245.15 1320.17,2245.15 v1(1375,2190.32) ; D18.2@1955,2042.76 1960,2037.76 v1(1960,2005)
  Bottom Layer w8: v1(1375,2190.32) 1397.68,2213 1489,2213 1602,2100 1602,2000 1671,1931 1886,1931 v1(1960,2005)
CHANNEL_4: D13.2 U1.54 | length 1021.2
  Top Layer w8: U1.54@1029.29,2264.83 1335.08,2265.24 v1(1430,2170.32) ; D13.2@1820,2315.12 1884.59,2315.12 v1(1885.61,2314.09)
  Signal Layer 2 w8: v1(1430,2170.32) 1741.83,2170.32 v1(1885.61,2314.09)
CHANNEL_5: D17.2 U1.55 | length 1006.2
  Top Layer w8: U1.55@1029.29,2284.52 1394.2,2284.52 v1(1430,2320.32) ; D17.2@1820,2042.76 1825,2037.76 v1(1825,2005)
  Bottom Layer w8: v1(1430,2320.32) 1552.68,2320.32 1825,2048 v1(1825,2005)
CHANNEL_6: D12.2 U1.56 | length 837.8
  Top Layer w8: U1.56@1029.29,2304.2 1338.89,2304.2 v1(1380,2345.32) ; D12.2@1680,2315.12 1749.59,2315.12 v1(1750.61,2314.09)
  Bottom Layer w8: v1(1380,2345.32) 1398.68,2364 1700.7,2364 v1(1750.61,2314.09)
CHANNEL_7: D16.2 U1.57 | length 937.5
  Top Layer w8: U1.57@1029.29,2323.89 1283.57,2323.89 v1(1330,2370.32) ; D16.2@1680.61,2042.76 1685,2038.37 v1(1685,2005)
  Bottom Layer w8: v1(1330,2370.32) 1330,2328 1383,2275 1495,2275 1685,2085 v1(1685,2005)
DRV_STATUS: D11.2 U1.35 | length 691.5
  Top Layer w8: v1@666.1,2085.06 U1.35@666.1,2137.87
  Top Layer w10: D11.2@1190.94,1899.34 v1(1190.94,1962.04)
  Bottom Layer w8: v1(665.78,2084.73) 705.51,2045 879,2045 911,2013 1139.98,2013 v1(1190.94,1962.04)
EZFET_AVBUS: C24.2 R56.1 R61.2 U2.1 | length 558.2
  Top Layer w10: 365,3935 365,3883.38 U2.1@383.81,3864.57
  Top Layer w12: 365,3935 v1(419.23,3989.23)
  Top Layer w20: v1(430,4250) R61.2@398.62,4250 R56.1@398.62,4200 C24.2@455.32,4200
  Signal Layer 1 w12: v1(419.23,3989.23) 419.23,4235.99 430,4246.75 v1(430,4250)
EZFET_AVCC2ADC: C22.2 R55.1 R60.2 U2.2 | length 412.1
  Top Layer w10: 374.73,3845.19 375.03,3844.89 390.34,3844.89 U2.2@390.62,3844.61
  Top Layer w12: 374.73,3845.19 345.13,3874.79 345.13,3957.74 398.62,4011.24 R60.2@398.62,4100
  Top Layer w20: R60.2@398.62,4100 R55.1@398.62,4150 C22.2@455.32,4150
EZFET_D_N: C42.1 R72.2 U2.52 | length 644.6
  Top Layer w10: U2.52@652.43,3889.89 652.7,3890.16 652.7,3904.06 664.48,3915.84 675.57,3915.84 709.73,3950 1136.5,3950 1165,3978.5 1165,3992.65 1159.14,3998.5 1154.84,3998.5 1150,4003.35 R72.2@1150,4005.31 1103.94,4005.31 C42.1@1100,4001.38
EZFET_D_P: C43.1 R75.2 R76.1 R77.2 U2.50 | length 720.9
  Top Layer w10: U2.50@691.8,3889.89 691.8,3903.78 718.02,3930 850.42,3930 ; R76.1@850,3884.69 850,3921.5 850.42,3921.91 850.42,3930 ; R77.2@925,3884.69 925,3921.5 925.14,3921.63 925.14,3930 ; C43.1@1250,4001.38 1246.06,4005.31 R75.2@1200,4005.31 1200,4003.35 1195.16,3998.5 1190.86,3998.5 1185,3992.65 1185,3970.22 1144.78,3930 925.14,3930 ; 850.42,3930 925.14,3930
EZFET_LED0: R58.1 U2.20 | length 178.5
  Top Layer w10: R58.1@375,3406.5 375,3407.48 475.26,3507.74 U2.20@475.26,3543.43
EZFET_LED1: R59.1 U2.21 | length 155.6
  Top Layer w10: R59.1@450,3406.5 450,3407.48 494.95,3452.43 U2.21@494.95,3543.43
EZFET_PUR: R76.2 U2.51 | length 222.7
  Top Layer w10: v1(670,3850) 670,3877 671.84,3878.84 671.84,3889.61 U2.51@672.11,3889.89
  Top Layer w12: v1(820,3850) 822.3,3847.7 847.61,3847.7 R76.2@850,3845.31
  Signal Layer 2 w12: v1(670,3850) v1(820,3850)
EZFET_RST: C23.2 J9.11 R57.1 U2.64 | length 1041.5
  Top Layer w8: v1(395,3920) 395,3918.18 416.21,3896.97 U2.64@416.21,3889.89
  Top Layer w12: J9.11@333.43,4542.4 387.07,4488.76 387.07,4395.89 398.62,4384.34 R57.1@398.62,4300 C23.2@445.47,4300
  Signal Layer 1 w12: J9.11@333.43,4542.4 287.07,4496.05 287.07,4359.52 339.89,4306.7 339.89,3975.11 v1(395,3920)
EZFET_TCK: J9.7 U2.63 | length 841.5
  Top Layer w8: v1(435,3855) 435.45,3855.45 435.45,3889.44 U2.63@435.89,3889.89
  Signal Layer 1 w12: v1(435,3855) 435,3908.41 429.13,3914.28 429.13,3922.47 387.07,3964.52 387.07,4461.6 421.52,4496.05 487.07,4496.05 J9.7@533.43,4542.4
EZFET_TDI: J9.3 U2.61 | length 829.4
  Top Layer w8: v1(475,3855) 475.13,3855.13 475.13,3889.76 U2.61@475.26,3889.89
  Bottom Layer w10: v1(475,3855) 475,3909.82 479.87,3914.7 479.87,4084.87 678.78,4283.78 678.78,4487.76 J9.3@733.43,4542.4
EZFET_TDO: J9.1 U2.60 | length 795.9
  Top Layer w8: U2.60@494.95,3889.89 494.95,3912.92 505,3922.97 v1(505,3925)
  Bottom Layer w10: v1(505,3925) 505,3928.79 501.13,3932.66 501.13,3981.13 778.78,4258.78 778.78,4487.76 J9.1@833.43,4542.4
EZFET_TEST: J9.8 U2.59 | length 635.2
  Top Layer w8: v1@514.63,3855.37 514.82,3855.55 514.82,3889.7 U2.59@514.63,3889.89
  Signal Layer 1 w15: v1(515,3855) 515,3857.44 540,3882.44 540,4435.83 J9.8@533.43,4442.4
EZFET_TMS: J9.5 U2.62 | length 765.1
  Top Layer w8: v1(455,3925) 455.29,3924.71 455.29,3890.18 U2.62@455.58,3889.89
  Signal Layer 1 w12: v1(455,3925) 480,3950 480,4454.53 521.52,4496.05 587.07,4496.05 J9.5@633.43,4542.4
EZFET_UARTRXD: R66.1 U2.38 | length 386.5
  Top Layer w10: R66.1@675,3367.72 677.87,3370.59 679.84,3370.59 696.57,3387.32 702.32,3387.32 v1(705,3390) ; U2.38@737.07,3667.45 768.89,3667.45 776.34,3660 v1(780.13,3660)
  Signal Layer 1 w10: v1(705,3390) 705,3584.87 v1(780.13,3660)
EZFET_UARTTXD: R67.1 U2.37 | length 358.5
  Top Layer w10: R67.1@600,3367.72 602.87,3370.59 604.84,3370.59 621.57,3387.32 627.32,3387.32 v1(630,3390) ; v1(705,3645) 707.49,3647.49 736.8,3647.49 U2.37@737.07,3647.76
  Signal Layer 1 w10: v1(630,3390) 630,3570 v1(705,3645)
EZFET_USB_Shield: C47.1 J11.6 J11.7 J11.8 J11.9 J11.10 J11.11 R78.2 | length 172.9
  Top Layer w10: v1(1367,4457.41) 1440.03,4457.41 C47.1@1447.44,4450 ; v1(1367.15,4496.16) 1451.16,4496.16 R78.2@1455,4500
  other v1: 985,4457 985.15,4495.75
EZFET_V18: C28.1 U2.55 | length 158.3
  Top Layer w10: U2.55@593.37,3889.89 593.65,3890.16 593.65,3904.06 668.41,3978.82 686.3,3978.82 700,3992.52 C28.1@700,3993.5
EZFET_VBUS: C20.2 C21.1 C35.1 C36.1 C37.1 C48.2 L1.2 R56.2 U2.53 U3.5 U3.8 U6.1 | length 2287.9
  Top Layer w8: v1(630,3850) 632.02,3852.02 632.02,3889.16 U2.53@632.74,3889.89
  Top Layer w12: U3.8@961.61,4255.12 961.61,4279.88 968.64,4286.91 1038.39,4286.91
  Top Layer w15: C48.2@850,4268.5 863.39,4255.12 869.99,4255.12 U3.8@961.61,4255.12 ; U3.5@1038.39,4255.12 1038.39,4286.91 1044.31,4292.84 1044.31,4308.8 1055.51,4320 C37.1@1056.5,4320 1059.77,4323.28 1098.28,4323.28 v1(1100,4325) 1135.25,4325 1144.04,4333.79 U6.1@1144.04,4340
  Top Layer w20: v1(312.94,4200) R56.2@351.38,4200 ; C35.1@625,4276.38 625,4235 v1(660,4200) 660.77,4200.77 694.27,4200.77 C36.1@700,4206.5 ; C20.2@1325,4175 1328.25,4178.25 1328.25,4246.75 1325,4250 1325,4326.93 ; L1.2@1327.56,4375 1325,4372.44 1325,4326.93 ; v1(1350,4325) 1349.23,4325.77 1326.16,4325.77 1325,4326.93
  Signal Layer 1 w15: v1(630,3850) 630,4170 v1(660,4200)
  Signal Layer 2 w20: v1(312.94,4200) v1(660,4200) 817.5,4200 942.5,4325 v1(1100,4325) v1(1350,4325)
EZFET_VCC: C31.2 C32.1 C33.1 C34.1 J2.1 J10.9 R55.2 R57.2 R62.2 R63.2 R68.1 U2.11 U2.15 U2.40 | length 3676
  Top Layer w10: C32.1@256.5,3650 266.5,3640 v1(340,3640) ; U2.15@390.62,3588.71 363.81,3588.71 340,3612.51 v1(340,3640) ; U2.11@390.62,3667.45 390.34,3667.17 367.17,3667.17 v1(340,3640) ; U2.40@737.07,3706.82 802.63,3706.82
  Top Layer w15: R62.2@700,4272.44 R63.2@775,4272.44 C33.1@775,4206.5 776.97,4204.53 848.03,4204.53 R68.1@850,4202.56 ; 802.63,3706.82 810.45,3699 855.14,3699 C31.2@879.13,3675
  Top Layer w20: v1(280,4150) R55.2@351.38,4150 ; v1(310,4300) R57.2@351.38,4300 ; C34.1@525,3343.5 525,3293.82 550.4,3268.42 550.4,3218.62 J10.9@559,3210.02 ; R63.2@775,4272.44 780.75,4278.19 781.73,4278.19 792.78,4289.23 809.23,4289.23 v1(810,4290) ; v1(840,3615) 840,3653.5 861.5,3675 C31.2@879.13,3675
  Signal Layer 1 w20: v1(310,4300) 280,4270 280,3700 v1(340,3640) 340,3432.25 559,3213.25 J10.9@559,3210.02
  Signal Layer 2 w20: v1(310,4300) 798.92,4300 808.92,4290 v1(810,4290) ; v1(340,3640) 384.87,3595.13 819.04,3595.13 838.92,3615 v1(840,3615)
  Bottom Layer w10: J2.1@160,3180 295.32,3180 314.7,3160.61 509.59,3160.61 J10.9@559,3210.02
EZFET_Vcore: C29.2 U2.17 | length 174.8
  Top Layer w12: 359.79,3543.43 U2.17@416.21,3543.43
  Top Layer w15: C29.2@254.53,3575 328.22,3575 359.79,3543.43
EZFET_VREF: C25.1 U2.9 | length 141.7
  Top Layer w12: C25.1@256.5,3725 312.05,3725 330.24,3706.82 U2.9@390.62,3706.82
EZFET_VUSB: C30.1 U2.54 | length 293.9
  Top Layer w10: v1(590,3850) 612.78,3872.78 612.78,3889.61 U2.54@613.06,3889.89 ; v1(739.23,3989.23) 770.73,3989.23 C30.1@775,3993.5
  Bottom Layer w10: v1(590,3850) 726.56,3986.56 736.56,3986.56 v1(739.23,3989.23)
EZFET_XT2IN: U2.57 Y1.1 | length 146.9
  Top Layer w10: U2.57@554,3889.89 554,3916.7 602.81,3965.51 606.54,3965.51 609.41,3968.38 Y1.1@609.41,4011.69
EZFET_XT2OUT: U2.58 Y1.3 | length 142.8
  Top Layer w10: Y1.3@491.3,4011.69 491.3,3968.38 494.17,3965.51 499.67,3965.51 534.32,3930.86 U2.58@534.32,3889.89
FAULT_STATUS: D3.2 U1.36 | length 1005.6
  Top Layer w8: v1(1335,2060) 1355,2040 D3.2@1355,1901.34
  Top Layer w10: v1@670.95,2233.05 685.79,2218.22 U1.36@685.79,2137.87
  Signal Layer 2 w10: v1(670.95,2236.84) 1071.16,2236.84 1248,2060 v1(1335,2060)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.1 C9.2 C10.2 C11.1 C12.2 C13.2 C14.2 C15.2 C16.2 C20.1 C21.2 C22.1 C23.1 C24.1 C25.2 C26.1 C27.1 C28.2 C29.1 C30.2 C31.1 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.1 C42.2 C43.2 C44.2 C45.2 C46.1 C47.2 C48.1 C49.1 C50.2 C51.1 C52.2 C53.2 C54.2 C55.2 C56.2 C59.1 D1.1 D2.1 D20.2 J4.4 J5.4 J7.2 J8.1 J9.9 J10.13 J10.14 J16.2 J17.2 J18.4 J19.4 J22.2 J23.2 J24.4 J25.4 J28.2 J29.2 L2.2 R30.2 R32.2 R43.1 R45.1 R47.1 R48.1 R49.1 R51.2 R52.2 R53.2 R60.1 R61.1 R77.1 R78.1 R80.1 R81.1 R82.1 R83.1 R84.1 R85.1 R86.1 R87.1 R88.1 R98.1 S1.3 S1.4 TP1.1 TP35.1 TP37.1 TP37.2 TP38.1 TP38.2 TP39.1 TP39.2 U1.10 U1.12 U1.15 U1.26 U1.29 U1.63 U1.76 U1.83 U1.90 U2.14 U2.16 U2.39 U2.49 U2.56 U2.65 U3.4 U3.9 U4.2 U4.3 U4.4 U4.5 U4.6 U4.7 U5.5 U5.25 U6.4 Y1.2 Y2.3 | length 1999.8
  Top Layer w8: v1(190,2380) 236.38,2380 C44.2@241.38,2375 ; v1(977.19,2442) U1.63@1029.29,2442 ; U5.25@3231.61,3101.61 v3(3270,3140) ; U5.25@3231.61,3178.39 v3(3270,3140) ; U5.5@3308.39,3252.4 3308.39,3178.39 v3(3270,3140) ; U5.25@3370,3105 3379.37,3114.37 C9.2@3485,3114.37
  Top Layer w10: U2.16@390.62,3569.02 390.89,3569.3 404.79,3569.3 442.32,3606.83 442.32,3622.32 v1(445,3625) ; U2.14@390.62,3608.39 424.6,3608.39 v1@441.21,3625 ; U1.15@421.02,2402.63 421.37,2402.98 450.88,2402.98 487.6,2439.69 487.6,2462.6 v1(490,2465) ; U1.12@421.02,2461.69 482.9,2461.69 486.21,2465 v1(490,2465) ; U1.10@421.02,2501.06 477.27,2501.06 478.53,2502.32 479.1,2502.32 480.71,2500.71 v1(485,2505) ; C49.1@455.41,2060.9 488.94,2094.43 U1.26@488.94,2137.87 489.28,2138.21 489.28,2167.72 508.88,2187.32 517.32,2187.32 v1(520,2190) 522.68,2187.32 528.05,2187.32 547.65,2167.72 547.65,2138.21 U1.29@547.99,2137.87 ; v1@480.25,2499.75 487.32,2492.68 487.32,2467.68 v1(490,2465) ; U2.65@563.84,3716.66 565.13,3717.94 565.13,3860.3 573.69,3868.86 U2.56@573.69,3889.89 ; v1(609.08,2815.31) 609.08,2819.1 616.3,2826.32 616.3,2834.8 C54.2@630,2848.5 630,2843.13 644.62,2828.51 645.61,2828.51 685.79,2788.33 U1.90@685.79,2746.13 ; v1(670,3690) 672.87,3687.13 U2.39@737.07,3687.13 ; U2.49@711.48,3889.89 U2.49@711.48,3889.89 739.94,3889.94 v1(740,3890) ; U1.83@823.58,2746.13 823.58,2700.21 835,2688.79 v1(835,2685) ; U1.76@961.38,2746.13 961.38,2745.84 962.21,2745 v1(990,2745) ; U3.4@1038.39,4144.88 1038.39,4150.59 1039.49,4151.69 1052.9,4151.69 1056.21,4155 v1(1060,4155) ; U6.4@1185,4363.62 1185,4365.59 1191.51,4372.1 1191.51,4377.24 v1(1194.19,4379.92)
  Top Layer w20: C40.2@925,4056.5 v1(925,4100) ; C39.2@1000,3993.5 1043.5,3993.5 v1(1050,4000) ; v1(2165.27,2039.16) 2165.44,2039.33 R88.1@2165.44,2071.36 ; v2(3399,3568) 3399.49,3568.49 3399.49,3600.26 R43.1@3399.98,3600.75 ; v2(4063.03,3529.52) C3.2@4063.03,3563.11 ; v2(4140,3523.09) C5.2@4140,3556.69 ; v2(4220,3523.09) C11.1@4220,3556.69 ; v2(4300,3529) C12.2@4300,3562.6
  other v1: 714,1656 1230,1685 1075,1690 1405,1690 265,1940 272,2142 150,2195 155,2295 665,2520 205,2560 175,2775 1635,3165 895,3290 640,3295 745,3295 560,3405 860,3405 570,3450 1325,3450 180,3540 1195,3545 180,3605 1020,3630 3032,3673 2638,3674 1110,3675 180,3685 1020,3720 450,3790 680,3790 129,3957 226,3957 740,4050 452,4094 1100,4095 1250,4095 740,4100 512.63,4170 919.23,4199.23 1265,4210 1095,4235 310,4250 510,4250 585,4330 705,4375 950,4375 1409,4391 900,4400 1505,4410 1555,4450 1520,4500 1440,4570
  other v2: 2901.01,2245.17 3451.01,2245.17 3051.01,2295.17 3351.01,2345.17 3451.01,2345.17 3051.01,2395.17 3351.01,2445.17 3051.01,2545.17 3051.01,2645.17 4025,2755 4201.01,2795.17 4151.01,2845.17 4251.01,2845.17 3391,2854 3465,3365 4433,3712
  other v3: 3128.27,3092.76 3175.51,3092.76 3222.76,3092.76 3270,3092.76 3317.24,3092.76 3364.49,3092.76 3411.73,3092.76 3128.27,3140 3175.51,3140 3222.76,3140 3317.24,3140 3364.49,3140 3411.73,3140 3128.27,3187.24 3175.51,3187.24 3222.76,3187.24 3270,3187.24 3317.24,3187.24 3364.49,3187.24 3411.73,3187.24
  other v4: 536.48,3642.84 591.21,3642.84 490.03,3689.3 536.48,3689.3 591.21,3689.3 637.66,3689.3 490.03,3744.02 536.48,3744.02 591.21,3744.02 637.66,3744.02 536.48,3790.48 591.21,3790.48 1000,4180.31 975.39,4200 1024.61,4200 1000,4219.69
GUI_STATUS: D10.2 U1.34 | length 709.4
  Top Layer w8: U1.34@646.42,2137.87 v1@646.42,2190.68
  Top Layer w10: D10.2@1032.04,1899.34 v1(1032.04,1962.04)
  Bottom Layer w10: v1(646.74,2191) 616,2160.26 616,2071 678,2009 861,2009 907.96,1962.04 v1(1032.04,1962.04)
ID0: R39.2 R51.1 U1.43 | length 1036.3
  Top Layer w8: v1(800,2204) 823.58,2180.42 U1.43@823.58,2137.87 ; v1(1095,2920) 1097.69,2920 1107.69,2910 1165,2910 ; R51.1@1165,2887.56 R39.2@1165,2932.44
  Bottom Layer w8: v1(800,2204) 800,2416.34 1098.87,2715.21 1098.87,2916.13 v1(1095,2920)
ID1: R40.2 R52.1 U1.44 | length 1132.3
  Top Layer w8: v1@843.27,2085.06 U1.44@843.27,2137.87 ; v1(1210,2910) 1248.48,2910 1252.2,2906.28 ; R52.1@1252.2,2882.56 1252.2,2906.28 ; R40.2@1252.2,2930 1252.2,2906.28
  Bottom Layer w8: v1(843.59,2084.73) 839.13,2089.19 839.13,2091.31 830,2100.44 830,2420.68 1210,2800.68 v1(1210,2910)
ID2: R41.2 R53.1 U1.45 | length 1038.8
  Top Layer w8: U1.45@862.95,2137.87 v1@862.95,2190.68 ; v1(1295,2910) 1334.47,2910 1335,2909.47 ; R53.1@1335,2885.75 1335,2909.47 ; R41.2@1335,2933.19 1335,2909.47
  Bottom Layer w8: v1(862.63,2191) 862.38,2191.24 862.38,2430.61 1295,2863.23 v1(1295,2910)
ID3: R30.1 R54.2 U1.46 | length 1187.1
  Top Layer w8: v1@882.64,2085.06 U1.46@882.64,2137.87 ; v1(1375,2910) 1417.97,2910 1420,2907.97 ; R30.1@1420,2884.25 1420,2907.97 ; R54.2@1420,2931.69 1420,2907.97
  Bottom Layer w8: v1(882.96,2084.73) 896,2097.77 896,2235 881.63,2249.37 881.63,2416.63 v1(1375,2910)
ID4: R31.2 R32.1 U1.47 | length 1156.9
  Top Layer w8: U1.47@902.32,2137.87 902.32,2177.32 v1(926,2201) ; v1(1465,2910) 1512.56,2910 1515,2912.44 ; R32.1@1515,2890 1515,2912.44 ; R31.2@1515,2934.88 1515,2912.44
  Bottom Layer w8: v1(926,2201) 926,2246 897.5,2274.5 897.5,2397.5 1350,2850 1405,2850 v1(1465,2910)
IN0: J7.5 TP22.1 U5.23 | length 1708
  Top Layer w8: J7.5@2025,2815 TP22.1@2156.65,2795 2335,2795 2354.29,2795 v1(2381.4,2795) v1@2390,2795 ; U5.23@3385.16,3027.6 3385.16,2986.52 v1(3421.67,2950)
  Signal Layer 2 w8: v1(2381.4,2795) 2381.4,2884.4 2487,2990 2594,2990 2705,2879 3350.67,2879 v1(3421.67,2950)
IN0_MCU: R94.1 U1.69 | length 416.8
  Top Layer w8: U1.69@1029.29,2560.11 1222.85,2560.11 1297.96,2485 R94.1@1415,2485
IN1: J7.7 TP23.1 U5.22 | length 1578
  Top Layer w8: J7.7@2025,2915 2146.65,2915 TP23.1@2161.65,2930 2164.15,2927.5 2367.5,2927.5 v1(2370,2925) ; U5.22@3359.57,3027.6 3359.78,3027.38 3359.78,2975.4 v1(3385.19,2950)
  Signal Layer 2 w8: v1(2370,2925) 2489,3044 2587,3044 2721,2910 3345.19,2910 v1(3385.19,2950)
IN1_MCU: R95.1 U1.70 | length 406.3
  Top Layer w8: U1.70@1029.29,2579.8 1242.65,2579.8 1292.45,2530 R95.1@1415,2530
MCU_3V3: C46.2 C51.2 C52.1 C53.1 C54.1 D5.2 J2.2 J7.4 J10.10 R9.2 R18.1 R19.2 R31.1 R37.1 R39.1 R40.1 R41.1 R54.1 TP36.1 U1.25 U1.64 U1.87 U1.89 | length 8605
  Top Layer w8: v1(960,2640) 960,2497.29 995.61,2461.69 U1.64@1029.29,2461.69 ; v1(1130,3015.15) 1157.6,2987.56 R39.1@1165,2987.56 ; v1(1215.42,3015.15) 1245.46,2985.12 R40.1@1252.2,2985.12 ; v1(1293.97,3015.15) 1320.82,2988.31 R41.1@1335,2988.31 ; v1(1383.68,3015.15) 1412.03,2986.81 R54.1@1420,2986.81 ; R31.1@1515,2990 1570,3045 v1(1570,3050)
  Top Layer w10: v1(175,2650) 195.16,2670.16 229.41,2670.16 232.28,2673.03 R9.2@232.28,2725 ; 317.79,2183.47 359.21,2183.47 v1(361.34,2181.34) 364.02,2184.02 376.62,2184.02 397.79,2205.19 420.43,2205.19 U1.25@421.02,2205.78 ; C54.1@630,2911.5 635.31,2906.18 664.62,2906.18 ; v1(689.23,2614.09) 691.91,2616.77 701.82,2616.77 744.87,2659.82 744.87,2691.23 744.84,2745.3 744.5,2745.64 744.5,2775.99 732.94,2787.55 708.83,2787.55 705.82,2784.54 705.82,2746.48 U1.89@705.47,2746.13 ; 704.86,2787.55 704.86,2806.7 665.57,2845.99 665.57,2905.24 664.62,2906.18 ; R18.1@725,2898.62 725,2899.37 718.19,2906.18 664.62,2906.18
  Top Layer w15: C51.2@277.84,2245.41 293.79,2245.41 317.79,2221.41 317.79,2183.47 317.79,2116.65 C53.1@328.52,2105.92 C52.1@328.52,2044.31 328.52,1983.5 C46.2@328.79,1983.23 ; C46.2@328.52,1983.23 328.52,1931.48 358.18,1901.82 386.95,1901.82 D5.2@391.87,1896.9 ; D5.2@388.54,1901.82 D5.2@396.79,1901.82 448.18,1901.82 490.37,1859.63 490.37,1714.63 630,1575 770,1575 919,1724 919,1936 1107.5,2124.5 1454.5,2124.5 1490,2160 1490,2385 1820,2715 J7.4@1925,2715 ; TP36.1@420,2935 J10.10@559,3110.02 630.92,3038.09 630.92,2911.5 C54.1@630,2911.5 ; v1(1500,3485) 1640,3625 1640,3950.11 1601.49,3988.62 R19.2@1580,3988.62
  Signal Layer 1 w10: v1(960,2640) 960,2809.82 1045,2894.82 1045,2930.15 1126.06,3011.21 v1@1130,3011.21 ; v1@1135,3011.21 v1@1135,3015
  Signal Layer 1 w15: v1(1500,3485) 1570,3415 v1(1570,3050)
  Signal Layer 2 w12: v1(175,2650) 414.16,2650 450.07,2614.09 v1(689.23,2614.09)
  Signal Layer 2 w15: J10.10@559,3110.02 654.02,3015 v1@1130,3015
  Bottom Layer w10: J2.2@160,3080 305,2935 TP36.1@420,2935 ; v1(175,2650) 175,2588.72 167.11,2580.82 167.11,2523.33 384.87,2305.56 384.87,2204.87 v1(361.34,2181.34) ; v1(1130,3015.15) v1(1215.42,3015.15) v1(1293.97,3015.15) v1(1383.68,3015.15) 1535.15,3015.15 v1(1570,3050)
MCU_STATUS: D8.2 TP19.1 U1.37 | length 327
  Top Layer w8: U1.37@705.47,2137.87 705.47,2090.53 714.26,2081.74 D8.2@714.26,1900.34 TP19.1@800,1905
MCU_UARTRXD: J10.8 U1.61 | length 888.2
  Top Layer w8: v1(800,2629.79) 800,2585.15 982.52,2402.63
  Top Layer w10: J10.8@659,3110.02 797.32,2971.7 797.32,2947.68 v1(800,2945) ; 982.52,2402.63 U1.61@1029.29,2402.63
  Signal Layer 1 w10: v1(800,2629.79) v1(800,2945)
MCU_UARTTXD: J10.6 U1.60 | length 950.1
  Top Layer w8: v1(800,2550) 967.02,2382.96
  Top Layer w10: 967.02,2382.96 U1.60@1029.28,2382.96
  Signal Layer 1 w10: J10.6@759,3110.02 880.13,2988.89 880.13,2723.83 890.08,2713.88 890.08,2640.08 v1(800,2550)
NetC15_1: C15.1 R9.1 U1.9 | length 365.8
  Top Layer w10: C15.1@281.5,2800 281.5,2740.75 267.72,2726.97 270.59,2724.09 270.59,2720.16 330.88,2659.87 330.88,2581.37 391.17,2521.09 420.68,2521.09 U1.9@421.02,2520.74
NetC26_2: C26.2 J10.1 R64.2 | length 211
  Top Layer w10: C26.2@900,3351.38 953.94,3351.38 970.16,3335.16 972.13,3335.16 R64.2@975,3332.28 ; J10.1@959,3210.02 959,3318.25 R64.2@973.03,3332.28
NetC27_2: C27.2 J10.3 R65.2 | length 236.7
  Top Layer w10: R65.2@750,3332.28 809.84,3332.28 C27.2@825,3347.44 ; C27.2@825,3351.38 C27.2@825,3347.44 ; J10.3@859,3210.02 825,3244.02 C27.2@825,3347.44
NetC38_1: C38.1 C40.1 R68.2 U3.1 | length 360.6
  Top Layer w12: R68.2@850,4147.44 850.98,4147.44 852.26,4146.16 850.81,4144.71 850.81,4113.69 885.34,4079.16 885.34,3993.5
  Top Layer w15: C38.1@850,3993.5 885.34,3993.5 920.69,3993.5 925,3997.81 C40.1@925,4001.38 ; R68.2@852.26,4146.16 960.33,4146.16 U3.1@961.61,4144.88
NetC39_1: C39.1 U3.3 | length 101.6
  Top Layer w12: C39.1@1000,4048.62 1000,4092.32 1012.8,4105.12 U3.3@1012.8,4144.88
NetC44_1: C44.1 U1.14 Y2.1 | length 180.7
  Top Layer w8: C44.1@288.62,2375 288.62,2411.32 308.54,2431.23 Y2.1@349.8,2431.23 358.72,2422.32 U1.14@421.02,2422.32
NetC45_1: C45.1 U1.13 Y2.2 | length 192.8
  Top Layer w10: C45.1@273.62,2525 273.62,2506.19 313.15,2466.66 Y2.2@349.8,2466.66 366.04,2466.66 390.36,2442.35 420.65,2442.35 U1.13@421.02,2442
NetC49_2: C49.2 U1.27 | length 79.4
  Top Layer w10: U1.27@508.62,2137.87 508.97,2137.52 508.97,2066.4 C49.2@514.47,2060.9
NetC50_1: C50.1 R37.2 U1.11 | length 275
  Top Layer w10: R37.2@267.72,2675 267.72,2648.82 281.5,2635.04 C50.1@281.5,2600 282.48,2600 343.67,2538.81 343.67,2529.21 391.17,2481.72 420.68,2481.72 U1.11@421.02,2481.37
NetD1_2: D1.2 R58.2 | length 659.7
  Top Layer w10: v1(240,3860) 241.5,3860 D1.2@275,3893.5 ; v1(330,3335) 333.79,3335 342.29,3343.5 R58.2@375,3343.5
  Signal Layer 1 w10: v1(240,3860) 240,3425 v1(330,3335)
NetD2_2: D2.2 R59.2 | length 740.9
  Top Layer w10: D2.2@175,3893.5 205,3863.5 v1(205,3860) ; v1(425,3305) 427.68,3307.68 427.68,3320.2 450,3342.52 R59.2@450,3343.5
  Bottom Layer w10: v1(205,3860) 205,3525 v1(425,3305)
NetD3_1: D3.1 R80.2 | length 71.1
  Top Layer w8: R80.2@1355,1747.56 D3.1@1355,1818.66
NetD5_1: D5.1 R49.2 | length 77.5
  Top Layer w25: R49.2@396.45,1751.62 396.62,1751.79 396.62,1828.81 D5.1@396.79,1828.98
NetD6_1: D6.1 R43.2 | length 77.3
  Top Layer w25: R43.2@3399.99,3659.81 D6.1@3399.99,3737.09
NetD8_1: D8.1 R45.2 | length 78.3
  Top Layer w25: R45.2@714.25,1749.15 714.25,1827.43 D8.1@714.29,1827.47
NetD10_1: D10.1 R47.2 | length 78.3
  Top Layer w25: R47.2@1032.04,1748.15 1032.04,1826.43 D10.1@1032.08,1826.47
NetD11_1: D11.1 R48.2 | length 78
  Top Layer w25: D11.1@1190.38,1825.92 1190.93,1825.37 R48.2@1190.93,1748.15
NetD12_1: D12.1 R81.2 | length 72
  Top Layer w8: D12.1@1680,2232.44 R81.2@1751.99,2233.63
NetD13_1: D13.1 R82.2 | length 75.7
  Top Layer w8: D13.1@1820,2231.76 1895.51,2231.76 R82.2@1895.61,2231.65
NetD14_1: D14.1 R83.2 | length 71.3
  Top Layer w8: D14.1@1955,2232.44 2023.96,2232.44 R83.2@2025.61,2234.09
NetD15_1: D15.1 R84.2 | length 70.7
  Top Layer w8: D15.1@2095,2231.76 2165.51,2231.76 R84.2@2165.61,2231.65
NetD16_1: D16.1 R85.2 | length 134.8
  Top Layer w8: D16.1@1680,2125.43 D16.1@1680.61,2125.43 ; R85.2@1744.27,2125.43 D16.1@1680.61,2125.43 ; R85.2@1750.61,2126.65 1749.39,2125.43 D16.1@1680.61,2125.43
NetD17_1: D17.1 R86.2 | length 80.5
  Top Layer w8: D17.1@1815.61,2125.43 D17.1@1820,2125.43 1894.39,2125.43 R86.2@1895.61,2126.65
NetD18_1: D18.1 R87.2 | length 139.8
  Top Layer w8: D18.1@1955,2125.43 D18.1@1955.61,2125.43 ; R87.2@2019.27,2125.43 D18.1@1955.61,2125.43 ; R87.2@2030.61,2126.65 2029.39,2125.43 D18.1@1955.61,2125.43
NetD19_1: D19.1 R88.2 | length 75.5
  Top Layer w8: D19.1@2090.61,2125.43 D19.1@2095,2125.43 2164.39,2125.43 R88.2@2165.61,2126.65
NetF1_2: F1.2 J8.2 TP2.1 | length 243
  Bottom Layer w50: TP2.1@3822,3363 4065,3363
  other v2: 4090,3160 4200,3160 4310,3160 4400,3160 4485,3160 4035,3230 4125,3235 4250,3235 4440,3240 4345,3245 4080,3310 4475,3310 4300,3315 4390,3315 4050,3405 4125,3405 4225,3405 4325,3405 4420,3405
NetJ1_1: J1.1 R1.1 | length 112.5
  Top Layer w8: J1.1@3465,2860 J1.1@3470,2855
  Top Layer w20: J1.1@3465,2860 R1.1@3465,2965.47
NetJ6_2: J6.2 S1.1 S1.2 | length 536.2
  Top Layer w15: S1.2@1142.2,3296.26 S1.1@1417.8,3296.26 1417.8,3227.71 J6.2@1282,3091.91
NetJ7_1: J7.1 TP20.1 | length 171.9
  Top Layer w8: J7.1@2025,2615 2076.65,2615 TP20.1@2161.65,2530
NetJ7_3: J7.3 TP21.1 | length 152.4
  Top Layer w8: J7.3@2025,2715 2106.65,2715 TP21.1@2156.65,2665
NetJ7_6: J7.6 R94.2 | length 599.9
  Top Layer w8: R94.2@1455,2485 1471.59,2484.39 1471.74,2484.39 1475.02,2484.39 1830.68,2815 J7.6@1925,2815
NetJ7_8: J7.8 R95.2 | length 627.6
  Top Layer w8: R95.2@1455,2530 1480.45,2529.45 1480.54,2529.45 ; 1480.58,2529.45 1483.84,2529.45 1891.85,2920.22 1905.43,2920.22 J7.8@1925,2915
NetJ7_10: J7.10 R96.2 | length 662.7
  Top Layer w8: R96.2@1455,2570 1485,2570 1785,2870 1785,2892.18 1787.53,2894.72 J7.10@1925,3015
NetJ7_14: J7.14 R92.2 | length 886.8
  Top Layer w8: R92.2@1455,2620 1500,2620 1765,2885 1765,3180 1810,3215 J7.14@1925,3215
NetJ7_16: J7.16 R91.2 | length 946.2
  Top Layer w8: R91.2@1455,2665 1500,2665 1745,2910 1745,3270 ; 1745.31,3270 1805,3315 J7.16@1925,3315
NetJ7_18: J7.18 R93.2 | length 1013.6
  Top Layer w8: R93.2@1455,2705 1500,2705 1720.87,2925.87 1720,3360 1800,3415 J7.18@1925,3415
NetJ7_20: J7.20 R90.2 | length 1080
  Top Layer w8: R90.2@1455,2745 1505,2745 1700,2940 1700,3450 1800,3515 J7.20@1925,3515
NetJ9_2: J9.2 R63.1 | length 139.6
  Top Layer w15: R63.1@775,4327.56 775.98,4327.56 833.43,4385 J9.2@833.43,4442.4
NetJ9_4: J9.4 R62.1 | length 129.3
  Top Layer w15: R62.1@700,4327.56 700.98,4327.56 733.43,4360 J9.4@733.43,4442.4
NetJ10_5: J10.5 R66.2 | length 157.1
  Top Layer w10: R66.2@675,3332.28 675,3294.02 J10.5@759,3210.02
NetJ10_7: J10.7 R67.2 | length 146.7
  Top Layer w10: R67.2@600,3332.28 600,3269.02 J10.7@659,3210.02
NetJ11_1: J11.1 L1.1 | length 118.6
  Top Layer w10: J11.1@1220.56,4469.57 1218.43,4424.79 1272.44,4375.98 L1.1@1272.44,4375
NetJ11_5: J11.5 L2.1 | length 143.7
  Top Layer w10: L2.1@1052.56,4375 1090,4375 1118.2,4403.2 J11.5@1118.2,4469.57
NetR3_1: R3.1 U4.8 | length 65.2
  Top Layer w20: U4.8@2891.57,3752.19 2891.57,3792.13 R3.1@2909.44,3810
NetR4_2: R4.2 U4.1 | length 63
  Top Layer w20: R4.2@2664.56,3810 2677,3797.56 U4.1@2677,3752.19
NetTP29_1: TP29.1 U1.42 | length 942.9
  Top Layer w10: v1(803,1975) 803.84,1975.84 803.84,2137.8 U1.42@803.9,2137.87
  Bottom Layer w10: TP29.1@170.44,1619.82 447.82,1619.82 v1(803,1975)
NetTP30_1: TP30.1 U1.16 | length 779.5
  Top Layer w10: v1(370,2382) 370.6,2382.6 420.68,2382.6 U1.16@421.02,2382.94
  Signal Layer 1 w10: TP30.1@170.44,1784.07 204.07,1784.07 235,1815 402,1977.58 402,2346.21 370,2378.21 v1(370,2382)
NetTP31_1: TP31.1 U1.88 | length 1665.9
  Top Layer w10: v1(720,2670.13) 720,2673.91 725.16,2679.07 U1.88@725.16,2746.13
  Signal Layer 1 w15: v1(118.64,2656.13) 118.64,1764.71 TP31.1@170.44,1701.94 TP31.1@172.4,1699.57
  Signal Layer 2 w12: v1(118.64,2656.13) 121.57,2656.13 141.31,2675.87 711,2675.87 716.75,2670.13 v1(720,2670.13)
NetTP32_1: TP32.1 U1.19 | length 454.3
  Top Layer w10: v1(320,2320) 323.79,2320 327.68,2323.89 U1.19@421.02,2323.89
  Bottom Layer w10: TP32.1@170.44,2030.44 170,2170 v1(320,2320)
NetTP33_1: TP33.1 U1.20 | length 493
  Top Layer w10: v1(350,2290) 353.79,2290 367.99,2304.2 U1.20@421.02,2304.2
  Bottom Layer w10: TP33.1@170.44,1948.32 201.87,1979.75 201.87,2018.21 201.87,2141.87 v1(350,2290)
NetTP34_1: TP34.1 U1.21 | length 551.7
  Top Layer w10: v1(360,2250) 360,2253.01 391.17,2284.17 420.68,2284.17 U1.21@421.02,2284.52
  Bottom Layer w10: TP34.1@170.44,1866.19 225,1920.75 225,2136 339,2250 v1(360,2250)
nSCS: J7.19 TP28.1 U5.1 | length 1701
  Top Layer w8: J7.19@2025,3515 2070,3515 2160,3605 v1(2360,3605) ; v1(3410,3315) 3410.37,3314.63 3410.37,3252.78 U5.1@3410.75,3252.4
  Signal Layer 2 w8: v1(2360,3605) 2380,3625 3235,3625 3410,3450 v1(3410,3315)
nSCS_MCU: R90.1 U1.67 | length 495.3
  Top Layer w8: U1.67@1029.29,2520.74 v5(1089.26,2520.74) ; v5(1391.44,2745) R90.1@1415,2745
  Bottom Layer w8: v5(1089.26,2520.74) 1089.26,2549.26 1285,2745 v5(1391.44,2745)
nSLEEP: J7.9 TP24.1 U5.21 | length 1485.8
  Top Layer w8: J7.9@2025,3015 2111.65,3015 TP24.1@2171.65,3075 v1(2370,3075) ; U5.21@3333.98,3027.6 3333.98,2966.04 v1(3350,2950.02)
  Signal Layer 2 w8: v1(2370,3075) 2602,3075 2726.98,2950.02 v1(3350,2950.02)
nSLEEP_MCU: R96.1 U1.71 | length 397.9
  Top Layer w8: U1.71@1029.29,2599.48 1256.7,2599.48 1286.18,2570 R96.1@1415,2570
OUT0_LS: C55.1 J12.1 TP3.1 U5.6 | length 2424.1
  Top Layer w15: U5.6@3282.8,3252.4 U5.6@3282.8,3254.17 v1(3282.8,3322.2)
  Top Layer w20: TP3.1@4067,2332 4131,2268 4379,2268 4419,2308 C55.1@4419,2368 4419,2510.15 J12.1@4418.52,2510.63
  Bottom Layer w20: v1(3282.8,3322.2) 3155.2,3322.2 3073,3240 3073,3012 3169.9,2915.1 3499,2915.1 4067,2347.1 TP3.1@4067,2332
OUT1_LS: C56.1 J13.1 TP5.1 U5.19 | length 2120.6
  Top Layer w15: 3282.8,2967.2 U5.19@3282.8,3025.83 U5.19@3282.8,3027.6
  Top Layer w20: 3282.8,2967.2 3282.8,2338.58 3415,2206.37 3894.63,2206.37 TP5.1@4096,2005 4403.33,2005 J13.1@4403.69,2005.35 ; C56.1@4418.52,1831.06 J13.1@4418.52,2003.42
OUT2_D: J5.2 J15.1 TP9.1 U5.7 | length 2096.8
  Top Layer w10: 3247.1,3439.9 3257.2,3429.8 U5.7@3257.2,3254.17
  Top Layer w20: 3247.1,3439.9 3229,3458 3229,3589.5 3271,3631.5 3271,3964 3359,4052 3851,4052 J15.1@3996,4197 ; J5.2@3896,4492 3996,4392 J15.1@3996,4197 ; TP9.1@4196,4197 J15.1@3996,4197
OUT2_S: J5.3 J17.1 TP10.1 U5.8 | length 1552.7
  Top Layer w10: 3220.31,3407.69 3231.61,3396.39 U5.8@3231.61,3254.17
  Top Layer w20: 3220.31,3407.69 3194,3434 3194,3604 3236,3646 3236,3991 TP10.1@3434,4189 3590,4189 J17.1@3594,4193 3594,4390 J5.3@3696,4492
OUT3_D: J19.2 J21.1 TP12.1 U5.18 | length 1628.4
  Top Layer w10: 3237,2890 3257.2,2910.2 U5.18@3257.2,3025.83
  Top Layer w20: 3237,2890 3237,2305 3468,2074 TP12.1@3594,2074 J21.1@3594,1915 3594,1812 3646,1760 J19.2@3646,1649
OUT3_S: J19.3 J23.1 TP14.1 U5.17 | length 2480
  Top Layer w10: 3208.5,2902.5 3231.61,2925.61 U5.17@3231.61,3025.83
  Top Layer w20: 3210.42,2900.58 3187,2877.16 3187,2288 3354.34,2120.66 3354.34,1620.66 3426,1549 3746,1549 J19.3@3846,1649 3845.5,1649.5 3845.5,2073.5 TP14.1@3845,2074
OUT4_D: J25.2 J27.1 TP16.1 U5.9 | length 1566.8
  Top Layer w10: 3186,3398 3206.02,3377.98 U5.9@3206.02,3254.17
  Top Layer w20: J25.2@2979,4492 2980,4491 2980,4194.34 2980,4039 TP16.1@2981,4038 2820.14,3877.14 2820.14,3590.28 2906.85,3503.57 3080.43,3503.57 3186,3398
OUT4_S: J25.3 J29.1 TP18.1 U5.10 | length 1522.5
  Top Layer w10: 3164,3374 3180.43,3357.57 U5.10@3180.43,3254.17
  Top Layer w20: J25.3@2779,4492 2779,4193 TP18.1@2779,4038 2779,3556.91 2882.91,3453 3085,3453 3164,3374
OUT5_D: J4.2 J14.1 TP7.1 U5.16 | length 1710
  Top Layer w10: 3206.02,2959 U5.16@3206.02,3025.83
  Top Layer w20: J4.2@2729,1649 J14.1@2729,1915 2729,2690 2920,2881 3151.42,2881 3206.02,2935.6 3206.02,2959
OUT5_S: J4.3 J16.1 TP8.1 U5.15 | length 2654
  Top Layer w10: 3164.22,2933.22 3180.43,2949.43 U5.15@3180.43,3025.83
  Top Layer w20: TP8.1@2928,2096 2928.5,2095.5 2928.5,1649.5 J4.3@2929,1649 2848,1568 2689,1568 2613,1644 2613,1796.5 2552,1857.5 2552,2068 2693,2209 2693,2732 2878,2917 3148,2917 3164.22,2933.22
OUT6_D: J18.2 J20.1 TP11.1 U5.12 | length 3043.1
  Top Layer w10: 3087.17,3254.17 U5.12@3129.25,3254.17
  Top Layer w20: TP11.1@2108,4038 J20.1@2108,4194.34 J18.2@2108,4492 2017,4583 1883,4583 1797.5,4497.5 1797.5,4351.5 1745.65,4299.65 1745.65,4010.35 1891,3865 2229,3865 2764,3330 3011.35,3330 3087.17,3254.17
OUT6_S: J18.3 J22.1 TP13.1 U5.11 | length 2068.7
  Top Layer w10: U5.11@3154.84,3254.17 3154.84,3332.94
  Top Layer w20: TP13.1@1908,4038 J18.3@1908,4492 ; TP13.1@1911,4038 2028.7,3920.3 2246.68,3920.3 2769.48,3397.5 3090.28,3397.5 3154.84,3332.94
OUT7_D: J24.2 J26.1 TP15.1 U5.13 | length 3039.8
  Top Layer w10: 3071,3025 3071.83,3025.83 U5.13@3129.25,3025.83
  Top Layer w20: TP15.1@1477,2007 1477,1717 1397,1637 J26.1@1397,1584 1755,1584 J24.2@1820,1649 1882,1649 2236,2003 2236,2437 2824,3025 3071,3025
OUT7_S: J24.3 J28.1 TP17.1 U5.14 | length 2106.6
  Top Layer w10: 3143,2959 3154.84,2970.84 U5.14@3154.84,3025.83
  Top Layer w20: J24.3@2020,1649 2021.21,1650.21 2021.21,1705.89 2233.66,1918.34 2346,1918.34 TP17.1@2346,2096 2346,2493 2812,2959 3143,2959
PUSH: J6.3 U1.38 | length 1145.3
  Top Layer w8: U1.38@725.16,2137.87 v1@725.16,2190.68
  Signal Layer 1 w8: v1(725.48,2191) 725.48,2306.48 1185,2766 1185,3088.91 J6.3@1182,3091.91
RST/SBWTDIO: C41.2 C59.2 J6.1 J10.4 R18.2 R19.1 U1.96 | length 2495.4
  Top Layer w8: v1(1460,3550) 1530.47,3620.47 1532.05,3940.47 ; C59.2@1485,3940.47 1579.09,3940.47 R19.1@1580,3941.38
  Top Layer w10: U1.96@567.68,2746.13 567.68,2858.89 575,2866.21 v1(575,2870) ; J6.1@1382,3091.91 1393.24,3103.15 1455.88,3103.15 1477.73,3125 1495.47,3125 C41.2@1540.47,3170
  Top Layer w15: v1(698.86,2869.1) 700.59,2867.38 712.94,2867.38 725,2855.31 R18.2@725,2851.38
  Signal Layer 1 w12: v1(698.86,2869.1) 698.86,2993.89 705.35,3000.38 705.35,3121.93 739.8,3156.37 812.65,3156.37 J10.4@859,3110.02 ; J6.1@1382,3091.91 1460,3169.91 v1(1460,3550)
  Signal Layer 2 w12: J10.4@859,3110.02 905.35,3156.37 1317.54,3156.37 1379.04,3094.87 J6.1@1379.04,3090
  Signal Layer 2 w15: v1(575,2870) 697.96,2870 v1(698.86,2869.1)
SCLK: J7.17 TP27.1 U5.2 | length 1690.4
  Top Layer w8: J7.17@2025,3415 2101.65,3415 TP27.1@2161.65,3475 ; TP27.1@2174.64,3487.98 TP27.1@2161.65,3475 ; v1(2360,3475) TP27.1@2161.65,3475 ; U5.2@3385.16,3252.4 v1(3385.16,3340.83)
  Signal Layer 2 w8: v1(2360,3475) 2475,3590 3220,3590 3382.9,3422.01 3385.16,3419.68 v1(3385.16,3340.83)
SCLK_MCU: R93.1 U1.62 | length 548.7
  Top Layer w8: U1.62@1029.29,2422.32 1030.02,2423.04 1083.22,2423.04 v5(1084.94,2424.77) ; v5(1391.44,2705) R93.1@1415,2705
  Bottom Layer w8: v5(1084.94,2424.77) 1120,2459.83 1120,2544.99 1280.37,2705.35 v5@1387.28,2705.35
SDI: J7.15 TP26.1 U5.4 | length 1869.4
  Top Layer w8: J7.15@2025,3315 2136.65,3315 TP26.1@2166.65,3345 v1(2360,3345) ; U5.4@3333.6,3254.55 v1@3333.6,3316.4
  Signal Layer 2 w8: v1(2360,3345) 2317,3302 2317,3204 2352,3169 2409,3169 2445,3205 2445,3317.43 2617.57,3490 3160,3490 v1(3333.23,3316.77)
SDI_MCU: R91.1 U1.65 | length 522.9
  Top Layer w8: U1.65@1029.29,2481.37 1072.42,2481.37 1097.63,2456.16 1152.78,2456.16 v5(1153.81,2457.19) ; v5(1391.44,2665) R91.1@1415,2665
  Bottom Layer w8: v5(1153.81,2457.19) 1153.81,2534.78 1284.45,2665.42 v5@1386.05,2665.42
SDO: J7.13 TP25.1 U5.3 | length 1727.5
  Top Layer w8: J7.13@2025,3215 2165.7,3215 TP25.1@2165.84,3214.86 ; TP25.1@2165.9,3214.93 TP25.1@2165.84,3214.86 ; v1(2364.18,3214.86) TP25.1@2165.84,3214.86 ; U5.3@3359.57,3252.4 3359.78,3252.62 3359.78,3369.78 v1(3360,3370)
  Signal Layer 2 w8: v1(2364.18,3214.86) 2364.18,3277.18 2642,3555 3210,3555 3360,3405 v1(3360,3370)