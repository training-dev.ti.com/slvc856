# Altium PCB DRV81602Q1_EVM_ASCII-042624.PcbDoc (part 2 of 5)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4575.07 x 3254.25 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 245 components, 136 nets, 685 pads, 291 vias.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
Clearance Clearance_6 [InNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P002') Or  InNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201') Or  InNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P018') Or  InNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P016')] p87: gap=10 ignorepadtopadclearanceinfootprint=TRUE except(0: Arc-Hole Track-Hole SMDPad-Hole THPad-Hole Via-Hole Fill-Hole Poly-Hole Region-Hole Text-Hole)
Clearance Clearance_5 [InNamedPolygon('TOP_LAYER_NONET_P072')] p88: gap=10 ignorepadtopadclearanceinfootprint=TRUE except(0: Arc-Hole Track-Hole SMDPad-Hole THPad-Hole Via-Hole Fill-Hole Poly-Hole Region-Hole Text-Hole)
Clearance Clearance_4 [InNamedPolygon('TOP_LAYER_VM_P123') Or  InNamedPolygon('TOP_LAYER_VM_P123') Or  InNamedPolygon('TOP_LAYER_VM_P123')] p89: gap=10 ignorepadtopadclearanceinfootprint=TRUE except(0: Arc-Hole Track-Hole SMDPad-Hole THPad-Hole Via-Hole Fill-Hole Poly-Hole Region-Hole Text-Hole)
Clearance Clearance_3 [InNamedPolygon('TOP_LAYER_VM_P042') Or  InNamedPolygon('TOP_LAYER_VM_P044') Or  InNamedPolygon('TOP_LAYER_OUT2_P040') Or  InNamedPolygon('TOP_LAYER_OUT1_P038')] p90: gap=10 ignorepadtopadclearanceinfootprint=TRUE except(0: Arc-Hole Track-Hole SMDPad-Hole THPad-Hole Via-Hole Fill-Hole Poly-Hole Region-Hole Text-Hole)
Clearance Clearance_2 [InNamedPolygon('TOP_LAYER_OUT2_P040')] p91: gap=10 ignorepadtopadclearanceinfootprint=TRUE except(0: Arc-Hole Track-Hole SMDPad-Hole THPad-Hole Via-Hole Fill-Hole Poly-Hole Region-Hole Text-Hole)
Clearance Clearance_1 [InNamedPolygon('TOP_LAYER_VM_P046')] p92: gap=5.98 ignorepadtopadclearanceinfootprint=TRUE except(0: Arc-Hole Track-Hole SMDPad-Hole THPad-Hole Via-Hole Fill-Hole Poly-Hole Region-Hole Text-Hole)
Clearance Clearance_Keepouts [((IsTrack Or IsArc) And Not InPoly) And IsFree and IsKeepOut vs ((IsTrack Or IsArc) And Not InPoly) And IsFree and IsKeepOut] p93: gap=0 ignorepadtopadclearanceinfootprint=FALSE
Clearance Clearance_Poly [InPolygon] p94: gap=25 ignorepadtopadclearanceinfootprint=TRUE
Clearance Clearance_FiducialMark [IsKeepOut and InComponentClass('FiducialMark') vs IsPad and InComponentClass('FiducialMark')] p95: gap=0 ignorepadtopadclearanceinfootprint=FALSE
Clearance [All] p96: gap=6 ignorepadtopadclearanceinfootprint=TRUE except(7.87: Arc-Poly Track-Poly SMDPad-Poly THPad-Poly Via-Poly Fill-Poly Poly-Poly Poly-Region)
ComponentClearance [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 gap=30 collisioncheckmode=3
ComponentClearance ComponentClearance_THtoTH [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=54 gap=30 collisioncheckmode=3 // Protel DXP Scope 2 Expression Was: IsThruComponent
ComponentClearance ComponentClearance_THtoSMT [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=53 gap=40 collisioncheckmode=3 // Protel DXP Scope 2 Expression Was: IsSMTComponent
ComponentClearance ComponentClearance_SmallPassives [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=508 gap=14.96 collisioncheckmode=3 // Protel DXP Scope 2 Expression Was: HasFootprint('0201*') or HasFootprint('0402*') or HasFootprint('0508') or HasFootprint('0603*') or HasFootprint('0612') or HasFootprint('0805*') or HasFootprint('0815*') or HasFootprint('0830*') or HasFootprint('1206*') or HasFootprint('1210*') or HasFootprint('1808*') or HasFootprint('1812*') or HasFootprint('1825*') or HasFootprint('2010*') or HasFootprint('2220*') or HasFootprint('2225*') or HasFootprint('2512*') or HasFootprint('2728*') or HasFootprint('3518*')
ComponentClearance ComponentClearance_MountingHoles [All] p0: scope1count=1 scope1_0_kind=ComponentClass scope1_0_value="Mounting Holes" scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 gap=250 collisioncheckmode=3
ComponentClearance ComponentClearance_ScrewToNut [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=71 gap=5 collisioncheckmode=3 // Protel DXP Scope 2 Expression Was: (HasFootprint('Keystone_1902C'))
ComponentClearance ComponentClearance_Logo [All] p0: scope1count=1 scope1_0_kind=ComponentClass scope1_0_value=Logo scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 gap=50 collisioncheckmode=3
ComponentClearance ComponentClearance_Shunt [All] p0: scope1count=1 scope1_0_kind=ComponentClass scope1_0_value=Shunt scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 gap=0 collisioncheckmode=3
ComponentClearance ComponentClearance_MountingHoles_FiducialMarks [All] p0: scope1count=1 scope1_0_kind=ComponentClass scope1_0_value="Mounting Holes" scope2count=1 scope2_0_kind=ComponentClass scope2_0_value=FiducialMark commentlength=0 gap=50 collisioncheckmode=3
ComponentClearance ComponentClearance_MountingHoles_FiducialMarks [InComponentClass('Mounting Holes') vs InComponentClass('FiducialMark')] p1: gap=50 collisioncheckmode=3 verticalgap=10 showdistances=FALSE
ComponentClearance ComponentClearance_Shunt [InComponentClass('Shunt')] p2: gap=0 collisioncheckmode=3 verticalgap=0 showdistances=FALSE
ComponentClearance ComponentClearance_Logo [InComponentClass('Logo')] p3: gap=50 collisioncheckmode=3 verticalgap=10 showdistances=FALSE
ComponentClearance ComponentClearance_ScrewToNut [(HasFootprint('NY PMS 440 0025 PH')) vs (HasFootprint('Keystone_1902C'))] p4: gap=5 collisioncheckmode=3 verticalgap=10 showdistances=FALSE
ComponentClearance ComponentClearance_MountingHoles [InComponentClass('Mounting Holes')] p5: gap=250 collisioncheckmode=3 verticalgap=100000 showdistances=FALSE
ComponentClearance ComponentClearance_SmallPassives [HasFootprint('0201*') or HasFootprint('0402*') or HasFootprint('0508') or HasFootprint('0603*') or HasFootprint('0612') or HasFootprint('0805*') or HasFootprint('0815*') or HasFootprint('0830*') or HasFootprint('1206*') or HasFootprint('1210*') or HasFootprint('1808*') or HasFootprint('1812*') or HasFootprint('1825*') or HasFootprint('2010*') or HasFootprint('2220*') or HasFootprint('2225*') or HasFootprint('2512*') or HasFootprint('2728*') or HasFootprint('3518*') vs HasFootprint('0201*') or HasFootprint('0402*') or HasFootprint('0508') or HasFootprint('0603*') or HasFootprint('0612') or HasFootprint('0805*') or HasFootprint('0815*') or HasFootprint('0830*') or HasFootprint('1206*') or HasFootprint('1210*') or HasFootprint('1808*') or HasFootprint('1812*') or HasFootprint('1825*') or HasFootprint('2010*') or HasFootprint('2220*') or HasFootprint('2225*') or HasFootprint('2512*') or HasFootprint('2728*') or HasFootprint('3518*')] p6: gap=14.96 collisioncheckmode=3 verticalgap=10 showdistances=FALSE
ComponentClearance ComponentClearance_THtoSMT [IsThruComponent vs IsSMTComponent] p7: gap=40 collisioncheckmode=3 verticalgap=30 showdistances=FALSE
ComponentClearance ComponentClearance_THtoTH [IsThruComponent vs IsThruComponent] p8: gap=30 collisioncheckmode=3 verticalgap=30 showdistances=FALSE
ComponentClearance [All] p9: gap=30 collisioncheckmode=3 verticalgap=10 showdistances=FALSE
DiffPairsRouting [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
DiffPairsRouting [All] p1: maxlimit=100 minlimit=10 mostfreqgap=10 toplayer_minwidth=6.3 toplayer_maxwidth=15 toplayer_prefwidth=10 midlayer1_minwidth=15 midlayer1_maxwidth=15 midlayer1_prefwidth=15 midlayer2_minwidth=15 midlayer2_maxwidth=15 midlayer2_prefwidth=15 bottomlayer_minwidth=6.3 bottomlayer_maxwidth=15 bottomlayer_prefwidth=10 maxuncoupledlength=1000
FabricationTestPointUsage TestPointUsage [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 valid=2 allowmultiple=FALSE
FabricationTestPointUsage TestPointUsage [All] p1: valid=2 allowmultiple=FALSE
FabricationTestpoint Testpoint [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 side=3 testpointundercomponent=TRUE minsize=40 maxsize=100 preferedsize=60 minholesize=0 maxholesize=40 preferedholesize=32 testpointgrid=1
FabricationTestpoint Testpoint [All] p1: side=3 testpointundercomponent=TRUE minsize=40 maxsize=100 preferedsize=60 minholesize=0 maxholesize=40 preferedholesize=32 testpointgrid=1 allowsidetop=TRUE allowsidebottom=TRUE usegrid=TRUE gridtolerance=0.01
FanoutControl Fanout_Small [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=84 // Protel DXP Scope 1 Expression Was: (CompPinCount < 5)   Fanout_Small (Default Rule)
FanoutControl Fanout_Default [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=30 // Fanout_Default (Default Rule)
FanoutControl Fanout_SOIC [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=71 // Protel DXP Scope 1 Expression Was: IsSOIC   Fanout_SOIC (Default Rule)
FanoutControl Fanout_BGA [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=69 // Protel DXP Scope 1 Expression Was: IsBGA   Fanout_BGA (Default Rule)
FanoutControl Fanout_LCC [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=69 // Protel DXP Scope 1 Expression Was: IsLCC   Fanout_LCC (Default Rule)
FanoutControl Fanout_LCC [IsLCC] p1: bgadir=Out bgaviamode=Centered fanoutstyle=Auto fanoutdirection=Alternating viagrid=1 // Fanout_LCC (Default Rule)
FanoutControl Fanout_BGA [IsBGA] p2: bgadir=Out bgaviamode=Centered fanoutstyle=Auto fanoutdirection=Alternating viagrid=1 // Fanout_BGA (Default Rule)
FanoutControl Fanout_Default [All] p4: bgadir=Out bgaviamode=Centered fanoutstyle=Auto fanoutdirection=Alternating viagrid=1 // Fanout_Default (Default Rule)
FanoutControl Fanout_Small [(CompPinCount < 5)] p5: bgadir=Out bgaviamode=Centered fanoutstyle=Auto fanoutdirection=OutThenIn viagrid=1 // Fanout_Small (Default Rule)
Height [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
HoleSize [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 absolutevalues=TRUE maxlimit=251 minlimit=7.87 maxpercent=80.000 minpercent=20.000
HoleSize [All] p1: absolutevalues=TRUE maxlimit=251 minlimit=7.87 maxpercent=80.000 minpercent=20.000
HoleToHoleClearance [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
HoleToHoleClearance [All] p1: gap=12 allowstackedmicrovias=TRUE
LayerPairs [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 enforce=TRUE
MinimumAnnularRing [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 minimumring=7.87
MinimumAnnularRing MinimumAnnularRing_ThermalPadVias [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=63 minimumring=5.91 // Protel DXP Scope 1 Expression Was: IsVia and InAnyComponent
MinimumAnnularRing MinimumAnnularRing_ThermalPadVias [IsVia and InAnyComponent] p1: minimumring=5.91
MinimumAnnularRing [All] p2: minimumring=7.87
MinimumSolderMaskSliver [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
MinimumSolderMaskSliver MinimumSolderMaskSliver_Logo [All] p0: scope1count=1 scope1_0_kind=ComponentClass scope1_0_value=Logo scope2count=1 scope2_0_kind=ComponentClass scope2_0_value=Logo commentlength=0
MinimumSolderMaskSliver MinimumSolderMaskSliver_Logo [InComponentClass('Logo') vs InComponentClass('Logo')] p1: minsoldermaskwidth=0.7
MinimumSolderMaskSliver [All] p2: minsoldermaskwidth=3.94
NetAntennae [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
PasteMaskExpansion [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 expansion=0
PlaneClearance [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 clearance=20
PlaneConnect [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 planeconnectstyle=Direct reliefexpansion=10 reliefentries=4 reliefconductorwidth=10 reliefairgap=10
PlaneConnect [All] p1: planeconnectstyle=Direct reliefexpansion=10 reliefentries=4 reliefconductorwidth=10 reliefairgap=10
PolygonConnect PolygonConnect_94 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=78 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_GND_P203')
PolygonConnect PolygonConnect_93 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=87 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P136')
PolygonConnect PolygonConnect_92 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P244')
PolygonConnect PolygonConnect_91 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_BOUT2_P242')
PolygonConnect PolygonConnect_90 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P239')
PolygonConnect PolygonConnect_89 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_BOUT1_P240')
PolygonConnect PolygonConnect_88 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_VM_P080')
PolygonConnect PolygonConnect_87 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P125')
PolygonConnect PolygonConnect_86 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_VM_P080')
PolygonConnect PolygonConnect_85 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_OUT2_P211')
PolygonConnect PolygonConnect_84 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_OUT1_P205')
PolygonConnect PolygonConnect_83 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_OUT1_P205')
PolygonConnect PolygonConnect_82 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=78 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_GND_P204')
PolygonConnect PolygonConnect_81 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_NONET_P237')
PolygonConnect PolygonConnect_80 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=75 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_GND_P086')
PolygonConnect PolygonConnect_79 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P229')
PolygonConnect PolygonConnect_78 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=75 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_GND_P086')
PolygonConnect PolygonConnect_77 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT1_P221')
PolygonConnect PolygonConnect_76 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT2_P173')
PolygonConnect PolygonConnect_75 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT2_P173')
PolygonConnect PolygonConnect_74 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT2_P173')
PolygonConnect PolygonConnect_73 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT1_P221')
PolygonConnect PolygonConnect_72 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=75 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_GND_P121')
PolygonConnect PolygonConnect_71 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=118 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT2_P173') Or  IsNamedPolygon('TOP_LAYER_OUT1_P129')
PolygonConnect PolygonConnect_70 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT2_P173')
PolygonConnect PolygonConnect_69 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT1_P129')
PolygonConnect PolygonConnect_68 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P085')
PolygonConnect PolygonConnect_67 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_P_IN_P174')
PolygonConnect PolygonConnect_66 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=82 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_NETF1_2_P203')
PolygonConnect PolygonConnect_65 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_VBAT_P165')
PolygonConnect PolygonConnect_64 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P167')
PolygonConnect PolygonConnect_63 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P167')
PolygonConnect PolygonConnect_62 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P171')
PolygonConnect PolygonConnect_61 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=80 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_GND_P199')
PolygonConnect PolygonConnect_60 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=84 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_NETF1_2_P196')
PolygonConnect PolygonConnect_59 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=81 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_VBAT_P197')
PolygonConnect PolygonConnect_58 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=81 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_P_IN_P198')
PolygonConnect PolygonConnect_57 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=80 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_3V3_P194')
PolygonConnect PolygonConnect_56 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_NETF1_2_P207')
PolygonConnect PolygonConnect_55 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VBAT_P223')
PolygonConnect PolygonConnect_54 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_P_IN_P227')
PolygonConnect PolygonConnect_53 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=75 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_GND_P086')
PolygonConnect PolygonConnect_52 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=259 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_VM_P177') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P179') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P160') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P175') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P181')
PolygonConnect PolygonConnect_51 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=87 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P136')
PolygonConnect PolygonConnect_50 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=86 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P132')
PolygonConnect PolygonConnect_49 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=84 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_MCU_3V3_P192')
PolygonConnect PolygonConnect_48 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=80 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_1_GND_P190')
PolygonConnect PolygonConnect_47 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=80 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_1_GND_P184')
PolygonConnect PolygonConnect_46 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=78 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_GND_P241')
PolygonConnect PolygonConnect_45 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=78 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_GND_P241')
PolygonConnect PolygonConnect_44 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_OUT2_P163')
PolygonConnect PolygonConnect_43 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_VM_P166')
PolygonConnect PolygonConnect_42 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_VM_P235')
PolygonConnect PolygonConnect_41 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_OUT1_P164')
PolygonConnect PolygonConnect_40 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=78 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_GND_P162')
PolygonConnect PolygonConnect_39 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_VM_P160')
PolygonConnect PolygonConnect_38 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=82 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_NONET_P138')
PolygonConnect PolygonConnect_37 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_1_VM_P146')
PolygonConnect PolygonConnect_36 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=80 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_GND_P156')
PolygonConnect PolygonConnect_35 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=91 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P219')
PolygonConnect PolygonConnect_34 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=79 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_1_VM_P144')
PolygonConnect PolygonConnect_33 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=124 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_1_VM_P148') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P148')
PolygonConnect PolygonConnect_32 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=80 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_1_GND_P154')
PolygonConnect PolygonConnect_31 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=82 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_NONET_P138')
PolygonConnect PolygonConnect_30 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=80 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_GND_P082')
PolygonConnect PolygonConnect_29 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=75 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_GND_P076')
PolygonConnect PolygonConnect_28 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=75 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_GND_P087')
PolygonConnect PolygonConnect_27 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=114 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P127') Or  IsNamedPolygon('TOP_LAYER_VM_P085')
PolygonConnect PolygonConnect_26 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=75 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_GND_P117')
PolygonConnect PolygonConnect_25 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=118 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT1_P129') Or  IsNamedPolygon('TOP_LAYER_OUT2_P173')
PolygonConnect PolygonConnect_24 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=82 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_2_NONET_P113')
PolygonConnect PolygonConnect_23 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=80 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_NONET_P115')
PolygonConnect PolygonConnect_22 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=82 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('SIGNAL_LAYER_1_NONET_P111')
PolygonConnect PolygonConnect_21 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_NONET_P083')
PolygonConnect PolygonConnect_20 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_NONET_P105')
PolygonConnect PolygonConnect_19 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT2_P107')
PolygonConnect PolygonConnect_18 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_NONET_P101')
PolygonConnect PolygonConnect_17 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT1_P103')
PolygonConnect PolygonConnect_16 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT1_P000')
PolygonConnect PolygonConnect_15 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_NONET_P093')
PolygonConnect PolygonConnect_14 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT2_P099')
PolygonConnect PolygonConnect_13 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=76 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_OUT1_P000')
PolygonConnect PolygonConnect_12 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=933 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_NONET_P079') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P078') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P077') Or  IsNamedPolygon('TOP_LAYER_NONET_P083') Or  IsNamedPolygon('BOTTOM_LAYER_NONET_P072') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P070') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P059') Or  IsNamedPolygon('TOP_LAYER_OUT2_P058') Or  IsNamedPolygon('BOTTOM_LAYER_NONET_P056') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P054') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P052') Or  IsNamedPolygon('TOP_LAYER_OUT1_P050') Or  IsNamedPolygon('BOTTOM_LAYER_VM_P044') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P042') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P040') Or  IsNamedPolygon('TOP_LAYER_VM_P038') Or  IsNamedPolygon('BOTTOM_LAYER_VM_P036') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P018') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P016') Or  IsNamedPolygon('TOP_LAYER_VM_P002')
PolygonConnect PolygonConnect_11 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=120 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_NONET_P089') Or  IsNamedPolygon('TOP_LAYER_NONET_P090')
PolygonConnect PolygonConnect_10 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=250 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P002') Or  IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201') Or  IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P018') Or  IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P016')
PolygonConnect PolygonConnect_9 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=154 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123')
PolygonConnect PolygonConnect_8 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_NONET_P072')
PolygonConnect PolygonConnect_7 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=77 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_NONET_P072')
PolygonConnect PolygonConnect_6 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P042')
PolygonConnect PolygonConnect_5 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P044')
PolygonConnect PolygonConnect_4 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=74 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_VM_P046')
PolygonConnect PolygonConnect_3 [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=159 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_GND_P036') Or  IsNamedPolygon('TOP_LAYER_OUT2_P040') Or  IsNamedPolygon('TOP_LAYER_OUT1_P038')
PolygonConnect PolygonConnect_2 [All] p0 off: scope1count=1 scope1_0_kind=Net scope1_0_value=EZFET_VBUS scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=82 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_EZFET_VBUS_P008')
PolygonConnect PolygonConnect_1 [All] p0 off: scope1count=1 scope1_0_kind=NetClass scope1_0_value=Power-Net scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=88 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" // Protel DXP Scope 2 Expression Was: IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201')
PolygonConnect [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle"
PolygonConnect PolygonConnect_94 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P203')] p1: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_93 [All vs IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P136')] p2: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_92 [All vs IsNamedPolygon('TOP_LAYER_VM_P244')] p3: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10