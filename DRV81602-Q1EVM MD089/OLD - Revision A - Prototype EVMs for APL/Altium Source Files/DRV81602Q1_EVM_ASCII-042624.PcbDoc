# Altium PCB DRV81602Q1_EVM_ASCII-042624.PcbDoc (part 4 of 5)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4575.07 x 3254.25 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 245 components, 136 nets, 685 pads, 291 vias.

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
0402 [mm] "0402 from SM-752 data"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -1.22,-0.52 1.22,0.52
0402L [mm] "0402 from SM-752 data"
  rect 0.6x0.5 smd: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.25,-0.51 0.25,0.51
0402S [mil] "Based on C0402S footprint from PADS legacy"
  rect 15x24 smd: 1(-20,0) 2(20,0)
  silkscreen extent -10,-20 10,20
0603 [mm] "0603 from SM-752 data"
  rect 1x0.95 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.52,-0.69 1.52,0.69
0603L [mm] "0603 from SM-752 data"
  rect 0.8x0.85 smd: 1(-0.7,0) 2(0.7,0)
  silkscreen extent -0.07,-0.33 0.07,0.33
0805_150 [mm] "0805 / 1.5 mm height"
  rect 1.15x1.45 smd: 1(-0.9,0) 2(0.9,0)
  silkscreen extent -0.1,-0.8 0.1,0.8
0805_A [mm] "Chip LED, 2-Leads, Body 2.0x1.3mm, IPC Medium Density"
  rect 1.1x1.2 smd: 1(-1.05,0) 2(1.05,0)
  silkscreen extent -0.15,-0.5 0.15,0.5
1206 [mm] "1206 from SM-752 data"
  rect 1.3x1.85 smd: 1(-1.45,0) 2(1.45,0)
  silkscreen extent -2.4,-1.21 2.4,1.21
691101710002 [mm] "5,00mm - modular - blue - Horizontal entry with pressure clamp - 12,6mm height - 02p"
  rect 1.95x1.95 hole 1.3: 1(-2.5,-0.5)
  round 1.95 hole 1.3: 2(2.5,-0.5)
  silkscreen extent -5.6,-4.5 5.6,4.5
CE_Mark_5mm [mil] "Minimum text height for CE Mark"
D0008A_N [mm] "SOIC, 8-Leads, Body 4.9x3.9mm, Pitch 1.27mm, IPC Medium Density"
  oval 1.45x0.6 smd: 1(-2.725,1.905) 2(-2.725,0.635) 3(-2.725,-0.635) 4(-2.725,-1.905) 5(2.725,-1.905) 6(2.725,-0.635) 7(2.725,0.635) 8(2.725,1.905)
  silkscreen extent -3.3,-2.5 0.9,2.5
DRB0008A [mm] "VSON-8"
  rrect32% 0.6x0.31 smd: 1(-1.4,0.975) 2(-1.4,0.325) 3(-1.4,-0.325) 4(-1.4,-0.975) 5(1.4,-0.975) 6(1.4,-0.325) 7(1.4,0.325) 8(1.4,0.975)
  rrect7% 1.5x1.75 smd paste-0.75: 9(0,0)
  silkscreen extent -1.73,-1.73 1.73,1.73
DRY0006A [mm] "USON-6"
  rrect67% 0.45x0.3 smd paste+0 mask+0: 1(-0.275,0.5)
  rrect67% 0.4x0.3 smd paste+0 mask+0: 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
  silkscreen extent -0.76,-0.98 0.76,0.98
Fiducial10-20 [mm]
  round 1 smd mask+0: 1(0,0)
  Top Layer keep-out circle w1.178: c0,0 r0.5
FP-0603-L_1_6_0_15-W_0_8-IPC_C [mil]
  rect 33.77x33.94 smd paste+0 mask+0: 1(-23.71,0) 2(23.71,0)
  silkscreen extent -41,-34 41,34
FP-150080SS75000-MFG [mm]
  rect 1.1x1.2 smd paste+0 mask+0: 1(-1.05,0) 2(1.05,0)
  silkscreen extent -2.27,-0.67 0.13,0.67
FP-1888700_HDR4-MFG [mm]
  rrect5% 2x2 hole 1.3 paste-1000 mask+0: 1(-7.62,0)
  round 2 hole 1.3 paste-1000 mask+0: 2(-2.54,0) 3(2.54,0) 4(7.62,0)
  silkscreen extent -10.77,-4.82 10.26,4.82
FP-430481025816_SMT_SW_6MM2_6MM2-MFG [mm]
  rrect7% 2x1.4 smd paste+0 mask+0: 1(-3.5,2) 2(3.5,2) 3(-3.5,-2) 4(3.5,-2)
  silkscreen extent -5.18,-3.2 3.2,3.2
FP-560050310009_0402-MFG [mm]
  rrect25% 0.4x0.5 smd paste+0 mask+0: 1(-0.45,0) 2(0.45,0)
  silkscreen extent -0.5,-0.63 0.5,0.63
FP-629105150921_CONN_PTH_USB_8MM0_5MM6-MFG [mm]
  rrect25% 0.4x1.35 smd paste+0 mask+0: 1(-1.3,2.335) 2(-0.65,2.335) 3(0,2.335) 4(0.65,2.335) 5(1.3,2.335)
  rrect100% 1.15x1.05 hole 0.65 slot 0.75 at 0 deg paste-1000 mask+0: 6(-2.225,2.65) 7(2.225,2.65)
  rrect100% 1.35x1.9 hole 1.3 slot 0.75 at 0 deg paste-1000 mask+0: 8(-4.175,-0.47) 11(4.173,-0.47)
  round 1.71 smd paste+0 mask+0: 8(-3.699,-0.47) 11(3.699,-0.47)
  rrect6% 1.8x1.9 smd paste+0 mask+0: 9(-1.15,-0.47) 10(1.15,-0.47)
  silkscreen extent -3.8,0.86 3.8,3.71
FP-691250610002_CONN_TERM_BLOCK2-MFG [mm]
  rrect4% 2.3x2.3 hole 1.5 paste-1000 mask+0: 1(-2.875,1.65)
  round 2.3 hole 1.5 paste-1000 mask+0: 2(3.475,1.65)
  silkscreen extent -7.52,-6.3 6.85,6.3
FP-875105240001_SMT_CAP_4MM3_4MM3-MFG [mm]
  rrect6% 2.6x1.6 smd paste+0 mask+0: 1(-1.8,0) 2(1.8,0)
  silkscreen extent -2.25,-2.25 4.09,3.25
FP-885012005058_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.53,-0.63 0.53,0.63
FP-885012006085_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-885012106012_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-885012205018_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.5,-0.63 0.5,0.63
FP-885012206050_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-885012206095-MFG [mm]
  rect 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-C0603C-CF-MFG [mm]
  rect 0.75x0.9 smd paste+0 mask+0: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -0.87,-0.85 0.88,0.85
FP-CC0603-DA-MFG [mm]
  rect 0.8x0.9 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.85 0.85,0.85
FP-SG73S1JTTD101J_0603-MFG [mm]
  rect 0.92x0.97 smd mask+0: 1(-0.775,0) 2(0.775,0)
  silkscreen extent -0.13,-0.45 0.13,0.45
FP-ZRB18AR61E106ME01L_0603-MFG [mm]
  rrect13% 0.75x0.9 smd paste+0 mask+0: 1(-0.775,0) 2(0.775,0)
  silkscreen extent 0,-0.5 0,0.5
Harwin_D3082-05 [mm] "Shorting Plug, 10.16mm spacing, TH"
  round 1.8 hole 1.3: 1(-5.08,0) 2(5.08,0)
  silkscreen extent -3.9,-0.53 3.9,0.53
IEC_Caution_Small [mil]
  silkscreen extent -107,-93 107,92
IEC_HotSurface_Small [mil]
  silkscreen extent -107,-93 107,92
Keystone5002 [mil] "For Keystone 500x miniature loop terminals"
  round 80 hole 40: 1(0,0)
  silkscreen extent -52,-52 52,52
Keystone5003 [mil] "For Keystone 500x miniature loop terminals"
  round 80 hole 40: 1(0,0)
  silkscreen extent -52,-52 52,52
Keystone5010 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
Keystone5011 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
Keystone5012 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
Label_650x200 [mil] "Thermal Transfer Label"
  round 1 on Mech13: 0(0,0)
  silkscreen extent -325,-100 325,100
MURATA_CSTNR [mm] "SMD, 3-Leads, Body 4.5x2mm, Pitch 1.5mm"
  rrect25% 0.4x2.6 smd: 1(-1.5,0) 2(0,0) 3(1.5,0)
  silkscreen extent -2.55,-1.3 2.55,1.3
PWP0024T-MFG [mm]
  rrect22% 1.5x0.45 smd paste+0 mask+0: 1(-2.9,3.575) 2(-2.9,2.925) 3(-2.9,2.275) 4(-2.9,1.625) 5(-2.9,0.975) 6(-2.9,0.325) 7(-2.9,-0.325) 8(-2.9,-0.975) 9(-2.9,-1.625) 10(-2.9,-2.275) 11(-2.9,-2.925) 12(-2.9,-3.575) 13(2.9,-3.575) 14(2.9,-2.925) 15(2.9,-2.275) 16(2.9,-1.625) 17(2.9,-0.975) 18(2.9,-0.325) 19(2.9,0.325) 20(2.9,0.975) 21(2.9,1.625) 22(2.9,2.275) 23(2.9,2.925) 24(2.9,3.575)
  rrect3% 3.4x7.8 smd paste+0 mask+0: 25(0,0)
  silkscreen extent -4.32,-4.28 2.25,4.28
PZT0100A_N [mm] "QFP, 100-Leads, Body 14x14mm, Pitch 0.50mm, IPC Medium Density"
  oval 1.45x0.3 smd: 1(-7.725,6) 2(-7.725,5.5) 3(-7.725,5) 4(-7.725,4.5) 5(-7.725,4) 6(-7.725,3.5) 7(-7.725,3) 8(-7.725,2.5) 9(-7.725,2) 10(-7.725,1.5) 11(-7.725,1) 12(-7.725,0.5) 13(-7.725,0) 14(-7.725,-0.5) 15(-7.725,-1) 16(-7.725,-1.5) 17(-7.725,-2) 18(-7.725,-2.5) 19(-7.725,-3) 20(-7.725,-3.5) 21(-7.725,-4) 22(-7.725,-4.5) 23(-7.725,-5) 24(-7.725,-5.5) 25(-7.725,-6) 51(7.725,-6) 52(7.725,-5.5) 53(7.725,-5) 54(7.725,-4.5) 55(7.725,-4) 56(7.725,-3.5) 57(7.725,-3) 58(7.725,-2.5) 59(7.725,-2) 60(7.725,-1.5) 61(7.725,-1) 62(7.725,-0.5) 63(7.725,0) 64(7.725,0.5) 65(7.725,1) 66(7.725,1.5) 67(7.725,2) 68(7.725,2.5) 69(7.725,3) 70(7.725,3.5) 71(7.725,4) 72(7.725,4.5) 73(7.725,5) 74(7.725,5.5) 75(7.725,6)
  oval 0.3x1.45 smd: 26(-6,-7.725) 27(-5.5,-7.725) 28(-5,-7.725) 29(-4.5,-7.725) 30(-4,-7.725) 31(-3.5,-7.725) 32(-3,-7.725) 33(-2.5,-7.725) 34(-2,-7.725) 35(-1.5,-7.725) 36(-1,-7.725) 37(-0.5,-7.725) 38(0,-7.725) 39(0.5,-7.725) 40(1,-7.725) 41(1.5,-7.725) 42(2,-7.725) 43(2.5,-7.725) 44(3,-7.725) 45(3.5,-7.725) 46(4,-7.725) 47(4.5,-7.725) 48(5,-7.725) 49(5.5,-7.725) 50(6,-7.725) 76(6,7.725) 77(5.5,7.725) 78(5,7.725) 79(4.5,7.725) 80(4,7.725) 81(3.5,7.725) 82(3,7.725) 83(2.5,7.725) 84(2,7.725) 85(1.5,7.725) 86(1,7.725) 87(0.5,7.725) 88(0,7.725) 89(-0.5,7.725) 90(-1,7.725) 91(-1.5,7.725) 92(-2,7.725) 93(-2.5,7.725) 94(-3,7.725) 95(-3.5,7.725) 96(-4,7.725) 97(-4.5,7.725) 98(-5,7.725) 99(-5.5,7.725) 100(-6,7.725)
  silkscreen extent -8.1,-8.2 8.1,8.2
RGC0064B [mm] "VQFN-64"
  rrect42% 0.6x0.24 smd mask+0: 1(-4.4,3.75) 2(-4.4,3.25) 3(-4.4,2.75) 4(-4.4,2.25) 5(-4.4,1.75) 6(-4.4,1.25) 7(-4.4,0.75) 8(-4.4,0.25) 9(-4.4,-0.25) 10(-4.4,-0.75) 11(-4.4,-1.25) 12(-4.4,-1.75) 13(-4.4,-2.25) 14(-4.4,-2.75) 15(-4.4,-3.25) 16(-4.4,-3.75) 33(4.4,-3.75) 34(4.4,-3.25) 35(4.4,-2.75) 36(4.4,-2.25) 37(4.4,-1.75) 38(4.4,-1.25) 39(4.4,-0.75) 40(4.4,-0.25) 41(4.4,0.25) 42(4.4,0.75) 43(4.4,1.25) 44(4.4,1.75) 45(4.4,2.25) 46(4.4,2.75) 47(4.4,3.25) 48(4.4,3.75)
  rrect42% 0.24x0.6 smd mask+0: 17(-3.75,-4.4) 18(-3.25,-4.4) 19(-2.75,-4.4) 20(-2.25,-4.4) 21(-1.75,-4.4) 22(-1.25,-4.4) 23(-0.75,-4.4) 24(-0.25,-4.4) 25(0.25,-4.4) 26(0.75,-4.4) 27(1.25,-4.4) 28(1.75,-4.4) 29(2.25,-4.4) 30(2.75,-4.4) 31(3.25,-4.4) 32(3.75,-4.4) 49(3.75,4.4) 50(3.25,4.4) 51(2.75,4.4) 52(2.25,4.4) 53(1.75,4.4) 54(1.25,4.4) 55(0.75,4.4) 56(0.25,4.4) 57(-0.25,4.4) 58(-0.75,4.4) 59(-1.25,4.4) 60(-1.75,4.4) 61(-2.25,4.4) 62(-2.75,4.4) 63(-3.25,4.4) 64(-3.75,4.4)
  rrect2% 4.25x4.25 smd paste+0: 65(0,0)
  silkscreen extent -4.75,-4.75 4.75,4.75
Samtec_HTSW-102-07-G-S [mm] "Samtec 100mil, 1x2, 230 mil above insulator"
  rrect6% 1.65x1.65 hole 1.016: 1(-1.27,0)
  round 1.65 hole 1.016: 2(1.27,0)
  silkscreen extent -3.3,-1.27 2.54,1.27
SM_RADIAL_G [mm] "10 x 10.2mm:  Panasonic G"
  rect 4.1x2 smd: 1(-4.35,0) 2(4.35,0)
  silkscreen extent -6.71,-5.35 5.35,5.35
SOD-123 [mm] "On Semi recommended land pattern"
  rect 0.915x1.22 smd: 1(-1.637,0) 2(1.637,0)
  silkscreen extent -2.74,-1.17 2.03,1.17
SULLINS_PEC10DAAN [mm] "SULLINS"
  rrect50% 1.55x1.55 hole 1.016: 1(-1.27,11.43)
  round 1.55 hole 1.016: 2(1.27,11.43) 3(-1.27,8.89) 4(1.27,8.89) 5(-1.27,6.35) 6(1.27,6.35) 7(-1.27,3.81) 8(1.27,3.81) 9(-1.27,1.27) 10(1.27,1.27) 11(-1.27,-1.27) 12(1.27,-1.27) 13(-1.27,-3.81) 14(1.27,-3.81) 15(-1.27,-6.35) 16(1.27,-6.35) 17(-1.27,-8.89) 18(1.27,-8.89) 19(-1.27,-11.43) 20(1.27,-11.43)
  silkscreen extent -2.9,-12.7 2.54,12.7
TI_Stacked_Overlay_Small [mil]
TP_H045P075 [mm] "TP_H0.45P0.75"
  round 0.75 hole 0.45: 1(0,0)
WE-HCC_1210 [mm] "WURTH"
  rect 2.9x5.4 smd: 1(-4.95,0) 2(4.95,0)
  silkscreen extent -6,-5.9 6,5.9
WEEE_Minimum [mil] "WEEElie bin"
  silkscreen extent 22,-71 54,74
WL-SMCW_GREEN [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8
WL-SMCW_RED [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8
Wurth_60900213421 [mil] "Shunt, 2.54mm, Black"
  round 1 on Mech3: 0(0,0)
WURTH_61300311121 [mm] "Header, 2.54mm, 3x1, TH"
  rrect50% 1.65x1.65 hole 1.15: 1(-2.54,0)
  round 1.65 hole 1.15: 2(0,0) 3(2.54,0)
  silkscreen extent -4.06,-1.52 4.06,1.52
WURTH_61301421121 [mm] "Header, 2.54mm, 7x2, TH"
  rrect50% 1.65x1.65 hole 1.1: 1(-1.27,7.62)
  round 1.65 hole 1.1: 2(1.27,7.62) 3(-1.27,5.08) 4(1.27,5.08) 5(-1.27,2.54) 6(1.27,2.54) 7(-1.27,0) 8(1.27,0) 9(-1.27,-2.54) 10(1.27,-2.54) 11(-1.27,-5.08) 12(1.27,-5.08) 13(-1.27,-7.62) 14(1.27,-7.62)
XTAL_MS3V-T1R [mm] "Micro Crystal Switzerland recommended land pattern"
  rect 1.1x0.6 smd: 1(-2.775,0.45) 2(-2.775,-0.45)
  rect 2.4x1.5 smd: 3(2.775,0)
  silkscreen extent -1.9,-0.74 1.2,0.74

## Part data
C1: library part CMP-0008507-2, "CAP, CERM, 0.068 uF, 100 V, +/- 10%, X7R, 1206"
C2: library part CMP-0094458-1, "10µF ±20% 25V Ceramic Capacitor X5R 0603 (1608 Metric)"
C3 C4: library part CMP-2000-07531-4, "Ceramic Capacitor General Use 1uF ±10% 50V X7R 0603"
C5 C10: library part CMP-207839-000004-1, "CAP CER 0.1UF 50V X7R 0603"
C6 C15 C21 C25 C32 C33 C34 C36 C46 C48 C50 C52 C53 C54: library part CMP-0006837-4, "CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, 0603"
C7: library part CMP-0078153-1, "CAP, CERM, 22 µF, 10 V,+/- 20%, X5R, 0805"
C8 C11: library part CMP-1035-02321-3, "CAP CER 10000PF 50V X7R 0603"
C9: library part CMP-0090362-1, "0.1µF ±10% 10V Ceramic Capacitor X7R 0402 (1005 Metric)"
C12 C16: library part CMP-03020-030804-1, "CAP CER 1000PF 50V X7R 0603"
C13 C14: library part CMP-0011178-2, "CAP, AL, 150 uF, 50 V, +/- 20%, 0.18 ohm, AEC-Q200 Grade 2, SMD"
C20: library part CMP-0097305-1, "4.7 µF ±20% 10V Ceramic Capacitor X5R 0603 (1608 Metric)"
C22 C24: library part CMP-0097306-1, "33 pF ±5% 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric)"
C23 C41 C59: library part CMP-0097311-1, "1000 pF ±5% 100V Ceramic Capacitor C0G, NP0 0603 (1608 Metric)"
C26 C27 C42 C43 C44 C45: library part CMP-0006215-2, "CAP, CERM, 10 pF, 50 V, +/- 5%, C0G/NP0, 0402"
C28 C30 C47: library part CMP-0006830-4, "CAP, CERM, 0.22 uF, 16 V, +/- 10%, X7R, 0603"
C29 C49: library part CMP-0097608-1, "0.47 µF ±10% 16V Ceramic Capacitor X7R 0603 (1608 Metric)"
C31 C51: library part CMP-0097340-1, "Alum. Polymer Cap 10µF 10V 5.5mmV-Chip WCAP-PSLP Series Lifetime 2000h +105°C"
C35 C40: library part CMP-0006831-4, "CAP, CERM, 1 uF, 16 V, +/- 10%, X7R, 0603"
C37 C39: library part CMP-0006828-4, "CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0603"
C38: library part CMP-0006825-5, "CAP, CERM, 2.2 uF, 16 V, +/- 20%, X5R, 0603"
C55 C56: library part CMP-0079993-1, "CAP, CERM, 0.01 µF, 100 V,+/- 10%, X7R, 0603"
D1: library part CMP-0002893-1, "LED, Super Red, SMD"
D2: library part CMP-0002894-2, "LED, Green, SMD"
D3: library part CMP-1426-00010-2, "LED RED CLEAR 0805 SMD"
D5 D6 D8 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19: library part CMP-1426-00009-1, "SMD mono-color Chip LED, WL-SMCW, Bright Green"
D20: library part CMP-0077592-3, "Diode, Zener, 2.7 V, 500 mW, SOD-123"
F1: library part CMP-0084439-1, "Fuse, 3 A, 32VAC/VDC, SMD"
FID1 FID2 FID3: library part CMP-0077181-1, "Fiducial mark.  There is nothing to buy or mount."
J1 J2 J14 J15 J16 J17 J20 J21 J22 J23 J26 J27 J28 J29: library part CMP-0075483-1, "Header, 100mil, 2x1, Gold, TH"
J4 J5 J18 J19 J24 J25: library part CMP-0086377-1, "Conn; Term Blk; PCB; Screw; 4; 5.08 mm; Front; 24-14 AWG; 16 A; 250 V; Solder"
J6: library part CMP-0054796-4, "Header, 2.54 mm, 3x1, Gold, TH"
J7: library part CMP-0054623-2, "Header, 2.54mm, 10x2, Tin, TH"
J8: library part CMP-0093233-2, "2 Position Wire to Board Terminal Block Horizontal with Board 0.250\" (6.35mm) Through Hole"
J9 J10: library part CMP-0086014-1, "Header, 2.54mm, 7x2, Gold, TH"
J11: library part CMP-0097752-1, "Conn Micro USB 2.0 Type AB RCP 5 POS 0.65mm Solder RA SMD 5 Terminal 1 Port T/R"
J12 J13: library part CMP-1502-03256-1, "Series 101 - 5.00 mm Horizontal Entry Modular with Pressure Clamp WR-TBL, 2 pin"
L1 L2: library part CMP-0003184-2, "Ferrite Bead, 140 ohm @ 100 MHz, 0.55 A, 0603"
L3: library part CMP-0063986-1, "Inductor, Shielded Drum Core, Ferrite, 1 uH, 24 A, 0.0012 ohm, SMD"
LBL1: library part CMP-0003625-1, "Thermal Transfer Printable Labels, 0.650\" W x 0.200\" H - 10,000 per roll"
Logo1: library part CMP-0074844-1
Logo2: library part CMP-0074838-1, "Texas Instrument Corporate Signature"
Logo4: library part CMP-0074769-3
Logo5: library part CMP-0074836-1, "IEC 61010-1 Caution Warning"
LOGO6: library part CMP-0074837-2, "IEC 61010-1 Hot Surface Warning"
R1: library part CMP-0095262-1, "100 Ohms ±5% 0.2W, 1/5W Chip Resistor 0603 (1608 Metric) Automotive AEC-Q200, Moisture Resistant, Pulse Withstanding Thick Film"
R3 R4 R62 R63 R68: library part CMP-0025697-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603"
R9 R37 R64 R65 R66 R67: library part CMP-0097401-1, "Thick Film Resistors 0402 10O ±1% 0.125W"
R18 R19 R57: library part CMP-0026935-3, "RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R30 R31 R32 R39 R40 R41 R51 R52 R53 R54: library part CMP-0025886-5, "RES, 10 k, 5%, 0.1 W, 0603"
R43: library part CMP-0082533-1, "RES, 4.99 k, 1%, 0.1 W, 0603"
R45 R47 R48 R49 R80 R81 R82 R83 R84 R85 R86 R87 R88: library part CMP-0025785-4, "RES, 330, 5%, 0.1 W, AEC-Q200 Grade 0, 0603"
R55 R60: library part CMP-0026728-1, "RES, 220 k, 1%, 0.0625 W, 0402"
R56: library part CMP-0026190-2, "RES, 240 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R58: library part CMP-0025924-5, "RES, 470, 5%, 0.1 W, 0603"
R59: library part CMP-0025930-5, "RES, 560, 5%, 0.1 W, 0603"
R61: library part CMP-0026021-3, "RES, 150 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R72 R75: library part CMP-0026888-3, "RES, 27, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R76: library part CMP-0026085-3, "RES, 1.40 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R77: library part CMP-0026859-2, "RES, 1.0 M, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R78: library part CMP-0026907-3, "RES, 33 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R90 R91 R92 R93 R94 R95 R96: library part CMP-0026722-1, "RES, 100, 1%, 0.063 W, 0402"
R97: library part CMP-0023620-3, "RES, 91.0 k, 0.1%, 0.1 W, 0603"
R98: library part CMP-0023404-3, "RES, 10.0 k, 0.1%, 0.1 W, 0603"
S1: library part CMP-0097347-1, "Tactile Switch SPST-NO Top Actuated Surface Mount"
SH-J1 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J19 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J31 SH-J32 SH-J33 SH-J34 SH-J35 SH-J36: library part CMP-0003761-2, "Shunt, 2.54mm, Gold, Black"
TP1 TP35: library part CMP-0055148-2, "Test Point, Multipurpose, Black, TH"
TP2 TP4 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 VM: library part CMP-0055147-2, "Test Point, Multipurpose, Red, TH"
TP3 TP5: library part CMP-0055149-2, "Test Point, Multipurpose, White, TH"
TP19 TP29 TP30 TP31 TP32 TP33 TP34: library part CMP-0003719-1, "Testpoint"
TP20 TP21 TP22 TP23 TP24 TP25 TP26 TP27 TP28: library part CMP-0055139-2, "Test Point, Miniature, White, TH"
TP36: library part CMP-0055140-2, "Test Point, Miniature, Orange, TH"
TP37 TP38 TP39: library part CMP-0075110-1, "1mm Uninsulated Shorting Plug, 10.16mm spacing, TH"
TP40 TP41: library part CMP-0055147-1, "Test Point, Multipurpose, Red, TH"
U1: library part CMP-0038879-1, "20 MHz Mixed Signal Microcontroller with 256 KB Flash, 18432 B SRAM and 74 GPIOs, -40 to 85 degC, 100-pin QFP (PZ), Green (RoHS & no Sb/Br)"
U2: library part CMP-0039269-4, "16-Bit Ultra-Low-Power Microcontroller, 128KB Flash, 8KB RAM, USB, 12Bit ADC, 2 USCIs, 32Bit HW MPY, RGC0064B (VQFN-64)"
U3: library part CMP-0036328-3, "500mA, Adjustable, Low Quiescent Current, Low-Noise, High-PSRR, Single-Output LDO Regulator, DRB0008A (VSON-8)"
U4: library part CMP-0070570-1, "Ultra-Low Quiescent Current Voltage Regulator, 8-pin Narrow SOIC, Pb-Free"
U5: library part CMP-0120420-1, "8-channel Configurable Low-side and High-side Driver for Automotive Relay, Lighting and Motor Control"
U6: library part CMP-0043099-3, "Low-Capacitance 2-Channel +/-15kV ESD Protection Array for High-Speed Data Interfaces, DRY0006A (USON-6)"
Y1: library part CMP-0085483-1, "Oscillator, 4 MHz, 700 ppm, 39 pF, SMD"
Y2: library part CMP-0004566-4, "Crystal, 32.768 kHz, 12.5pF, SMD"

## Via types
v1: diameter 24, hole 16, Top Layer to Bottom Layer, tented both sides, 184 vias
v2: diameter 24, hole 8, Top Layer to Bottom Layer, tented both sides, 61 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 21 vias
v4: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 16 vias
v5: diameter 20, hole 10, Top Layer to Bottom Layer, tented both sides, 9 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
CHANNEL_0: D15.2 U1.50 | length 1509.6
  Top Layer w8: v1@961.38,2085.06 U1.50@961.38,2137.87 ; D15.2@2095,2315.12 2159.59,2315.12 v1(2160.61,2314.09)
  Bottom Layer w8: v1(961.7,2084.73) 1307.97,2431 2043.7,2431 v1(2160.61,2314.09)
CHANNEL_1: D19.2 U1.51 | length 1330.4
  Top Layer w8: U1.51@1029.29,2205.78 1249.54,2205.78 v1(1280,2175.32) ; v1(2095,2000) 2091.1,2037.97 D19.2@2095,2042.76
  Bottom Layer w8: v1(1280,2175.32) 1311.41,2143.91 1510.09,2143.91 1582,2072 1582,1987 1672,1897 1992,1897 v1(2095,2000)
CHANNEL_2: D14.2 U1.52 | length 1171.2
  Top Layer w8: U1.52@1029.29,2225.46 1294.85,2225.46 v1(1325,2195.32) ; D14.2@1955,2315.12 1956.02,2314.09 v1(2025.61,2314.09)
  Signal Layer 2 w8: v1(1325,2195.32) 1358.68,2229 1727,2229 1863,2365 1974.7,2365 v1(2025.61,2314.09)
CHANNEL_3: D18.2 U1.53 | length 1208.7
  Top Layer w8: U1.53@1029.29,2245.15 1320.17,2245.15 v1(1375,2190.32) ; D18.2@1955,2042.76 1960,2037.76 v1(1960,2005)
  Bottom Layer w8: v1(1375,2190.32) 1397.68,2213 1489,2213 1602,2100 1602,2000 1671,1931 1886,1931 v1(1960,2005)
CHANNEL_4: D13.2 U1.54 | length 1021.2
  Top Layer w8: U1.54@1029.29,2264.83 1335.08,2265.24 v1(1430,2170.32) ; D13.2@1820,2315.12 1884.59,2315.12 v1(1885.61,2314.09)
  Signal Layer 2 w8: v1(1430,2170.32) 1741.83,2170.32 v1(1885.61,2314.09)
CHANNEL_5: D17.2 U1.55 | length 1006.2
  Top Layer w8: U1.55@1029.29,2284.52 1394.2,2284.52 v1(1430,2320.32) ; D17.2@1820,2042.76 1825,2037.76 v1(1825,2005)
  Bottom Layer w8: v1(1430,2320.32) 1552.68,2320.32 1825,2048 v1(1825,2005)
CHANNEL_6: D12.2 U1.56 | length 837.8
  Top Layer w8: U1.56@1029.29,2304.2 1338.89,2304.2 v1(1380,2345.32) ; D12.2@1680,2315.12 1749.59,2315.12 v1(1750.61,2314.09)
  Bottom Layer w8: v1(1380,2345.32) 1398.68,2364 1700.7,2364 v1(1750.61,2314.09)
CHANNEL_7: D16.2 U1.57 | length 937.5
  Top Layer w8: U1.57@1029.29,2323.89 1283.57,2323.89 v1(1330,2370.32) ; D16.2@1680.61,2042.76 1685,2038.37 v1(1685,2005)
  Bottom Layer w8: v1(1330,2370.32) 1330,2328 1383,2275 1495,2275 1685,2085 v1(1685,2005)
DRV_STATUS: D11.2 U1.35 | length 691.5
  Top Layer w8: v1@666.1,2085.06 U1.35@666.1,2137.87
  Top Layer w10: D11.2@1190.94,1899.34 v1(1190.94,1962.04)
  Bottom Layer w8: v1(665.78,2084.73) 705.51,2045 879,2045 911,2013 1139.98,2013 v1(1190.94,1962.04)
EZFET_AVBUS: C24.2 R56.1 R61.2 U2.1 | length 558.2
  Top Layer w10: 365,3935 365,3883.38 U2.1@383.81,3864.57
  Top Layer w12: 365,3935 v1(419.23,3989.23)
  Top Layer w20: v1(430,4250) R61.2@398.62,4250 R56.1@398.62,4200 C24.2@455.32,4200
  Signal Layer 1 w12: v1(419.23,3989.23) 419.23,4235.99 430,4246.75 v1(430,4250)
EZFET_AVCC2ADC: C22.2 R55.1 R60.2 U2.2 | length 412.1
  Top Layer w10: 374.73,3845.19 375.03,3844.89 390.34,3844.89 U2.2@390.62,3844.61
  Top Layer w12: 374.73,3845.19 345.13,3874.79 345.13,3957.74 398.62,4011.24 R60.2@398.62,4100
  Top Layer w20: R60.2@398.62,4100 R55.1@398.62,4150 C22.2@455.32,4150
EZFET_D_N: C42.1 R72.2 U2.52 | length 644.6
  Top Layer w10: U2.52@652.43,3889.89 652.7,3890.16 652.7,3904.06 664.48,3915.84 675.57,3915.84 709.73,3950 1136.5,3950 1165,3978.5 1165,3992.65 1159.14,3998.5 1154.84,3998.5 1150,4003.35 R72.2@1150,4005.31 1103.94,4005.31 C42.1@1100,4001.38
EZFET_D_P: C43.1 R75.2 R76.1 R77.2 U2.50 | length 720.9
  Top Layer w10: U2.50@691.8,3889.89 691.8,3903.78 718.02,3930 850.42,3930 ; R76.1@850,3884.69 850,3921.5 850.42,3921.91 850.42,3930 ; R77.2@925,3884.69 925,3921.5 925.14,3921.63 925.14,3930 ; C43.1@1250,4001.38 1246.06,4005.31 R75.2@1200,4005.31 1200,4003.35 1195.16,3998.5 1190.86,3998.5 1185,3992.65 1185,3970.22 1144.78,3930 925.14,3930 ; 850.42,3930 925.14,3930
EZFET_LED0: R58.1 U2.20 | length 178.5
  Top Layer w10: R58.1@375,3406.5 375,3407.48 475.26,3507.74 U2.20@475.26,3543.43
EZFET_LED1: R59.1 U2.21 | length 155.6
  Top Layer w10: R59.1@450,3406.5 450,3407.48 494.95,3452.43 U2.21@494.95,3543.43
EZFET_PUR: R76.2 U2.51 | length 222.7
  Top Layer w10: v1(670,3850) 670,3877 671.84,3878.84 671.84,3889.61 U2.51@672.11,3889.89
  Top Layer w12: v1(820,3850) 822.3,3847.7 847.61,3847.7 R76.2@850,3845.31
  Signal Layer 2 w12: v1(670,3850) v1(820,3850)
EZFET_RST: C23.2 J9.11 R57.1 U2.64 | length 1041.5
  Top Layer w8: v1(395,3920) 395,3918.18 416.21,3896.97 U2.64@416.21,3889.89
  Top Layer w12: J9.11@333.43,4542.4 387.07,4488.76 387.07,4395.89 398.62,4384.34 R57.1@398.62,4300 C23.2@445.47,4300
  Signal Layer 1 w12: J9.11@333.43,4542.4 287.07,4496.05 287.07,4359.52 339.89,4306.7 339.89,3975.11 v1(395,3920)
EZFET_TCK: J9.7 U2.63 | length 841.5
  Top Layer w8: v1(435,3855) 435.45,3855.45 435.45,3889.44 U2.63@435.89,3889.89
  Signal Layer 1 w12: v1(435,3855) 435,3908.41 429.13,3914.28 429.13,3922.47 387.07,3964.52 387.07,4461.6 421.52,4496.05 487.07,4496.05 J9.7@533.43,4542.4
EZFET_TDI: J9.3 U2.61 | length 829.4
  Top Layer w8: v1(475,3855) 475.13,3855.13 475.13,3889.76 U2.61@475.26,3889.89
  Bottom Layer w10: v1(475,3855) 475,3909.82 479.87,3914.7 479.87,4084.87 678.78,4283.78 678.78,4487.76 J9.3@733.43,4542.4
EZFET_TDO: J9.1 U2.60 | length 795.9
  Top Layer w8: U2.60@494.95,3889.89 494.95,3912.92 505,3922.97 v1(505,3925)
  Bottom Layer w10: v1(505,3925) 505,3928.79 501.13,3932.66 501.13,3981.13 778.78,4258.78 778.78,4487.76 J9.1@833.43,4542.4
EZFET_TEST: J9.8 U2.59 | length 635.2
  Top Layer w8: v1@514.63,3855.37 514.82,3855.55 514.82,3889.7 U2.59@514.63,3889.89
  Signal Layer 1 w15: v1(515,3855) 515,3857.44 540,3882.44 540,4435.83 J9.8@533.43,4442.4
EZFET_TMS: J9.5 U2.62 | length 765.1
  Top Layer w8: v1(455,3925) 455.29,3924.71 455.29,3890.18 U2.62@455.58,3889.89
  Signal Layer 1 w12: v1(455,3925) 480,3950 480,4454.53 521.52,4496.05 587.07,4496.05 J9.5@633.43,4542.4
EZFET_UARTRXD: R66.1 U2.38 | length 386.5
  Top Layer w10: R66.1@675,3367.72 677.87,3370.59 679.84,3370.59 696.57,3387.32 702.32,3387.32 v1(705,3390) ; U2.38@737.07,3667.45 768.89,3667.45 776.34,3660 v1(780.13,3660)
  Signal Layer 1 w10: v1(705,3390) 705,3584.87 v1(780.13,3660)
EZFET_UARTTXD: R67.1 U2.37 | length 358.5
  Top Layer w10: R67.1@600,3367.72 602.87,3370.59 604.84,3370.59 621.57,3387.32 627.32,3387.32 v1(630,3390) ; v1(705,3645) 707.49,3647.49 736.8,3647.49 U2.37@737.07,3647.76
  Signal Layer 1 w10: v1(630,3390) 630,3570 v1(705,3645)
EZFET_USB_Shield: C47.1 J11.6 J11.7 J11.8 J11.9 J11.10 J11.11 R78.2 | length 172.9
  Top Layer w10: v1(1367,4457.41) 1440.03,4457.41 C47.1@1447.44,4450 ; v1(1367.15,4496.16) 1451.16,4496.16 R78.2@1455,4500
  other v1: 985,4457 985.15,4495.75
EZFET_V18: C28.1 U2.55 | length 158.3
  Top Layer w10: U2.55@593.37,3889.89 593.65,3890.16 593.65,3904.06 668.41,3978.82 686.3,3978.82 700,3992.52 C28.1@700,3993.5
EZFET_VBUS: C20.2 C21.1 C35.1 C36.1 C37.1 C48.2 L1.2 R56.2 U2.53 U3.5 U3.8 U6.1 | length 2287.9
  Top Layer w8: v1(630,3850) 632.02,3852.02 632.02,3889.16 U2.53@632.74,3889.89
  Top Layer w12: U3.8@961.61,4255.12 961.61,4279.88 968.64,4286.91 1038.39,4286.91
  Top Layer w15: C48.2@850,4268.5 863.39,4255.12 869.99,4255.12 U3.8@961.61,4255.12 ; U3.5@1038.39,4255.12 1038.39,4286.91 1044.31,4292.84 1044.31,4308.8 1055.51,4320 C37.1@1056.5,4320 1059.77,4323.28 1098.28,4323.28 v1(1100,4325) 1135.25,4325 1144.04,4333.79 U6.1@1144.04,4340
  Top Layer w20: v1(312.94,4200) R56.2@351.38,4200 ; C35.1@625,4276.38 625,4235 v1(660,4200) 660.77,4200.77 694.27,4200.77 C36.1@700,4206.5 ; C20.2@1325,4175 1328.25,4178.25 1328.25,4246.75 1325,4250 1325,4326.93 ; L1.2@1327.56,4375 1325,4372.44 1325,4326.93 ; v1(1350,4325) 1349.23,4325.77 1326.16,4325.77 1325,4326.93
  Signal Layer 1 w15: v1(630,3850) 630,4170 v1(660,4200)
  Signal Layer 2 w20: v1(312.94,4200) v1(660,4200) 817.5,4200 942.5,4325 v1(1100,4325) v1(1350,4325)
EZFET_VCC: C31.2 C32.1 C33.1 C34.1 J2.1 J10.9 R55.2 R57.2 R62.2 R63.2 R68.1 U2.11 U2.15 U2.40 | length 3676
  Top Layer w10: C32.1@256.5,3650 266.5,3640 v1(340,3640) ; U2.15@390.62,3588.71 363.81,3588.71 340,3612.51 v1(340,3640) ; U2.11@390.62,3667.45 390.34,3667.17 367.17,3667.17 v1(340,3640) ; U2.40@737.07,3706.82 802.63,3706.82
  Top Layer w15: R62.2@700,4272.44 R63.2@775,4272.44 C33.1@775,4206.5 776.97,4204.53 848.03,4204.53 R68.1@850,4202.56 ; 802.63,3706.82 810.45,3699 855.14,3699 C31.2@879.13,3675
  Top Layer w20: v1(280,4150) R55.2@351.38,4150 ; v1(310,4300) R57.2@351.38,4300 ; C34.1@525,3343.5 525,3293.82 550.4,3268.42 550.4,3218.62 J10.9@559,3210.02 ; R63.2@775,4272.44 780.75,4278.19 781.73,4278.19 792.78,4289.23 809.23,4289.23 v1(810,4290) ; v1(840,3615) 840,3653.5 861.5,3675 C31.2@879.13,3675
  Signal Layer 1 w20: v1(310,4300) 280,4270 280,3700 v1(340,3640) 340,3432.25 559,3213.25 J10.9@559,3210.02
  Signal Layer 2 w20: v1(310,4300) 798.92,4300 808.92,4290 v1(810,4290) ; v1(340,3640) 384.87,3595.13 819.04,3595.13 838.92,3615 v1(840,3615)
  Bottom Layer w10: J2.1@160,3180 295.32,3180 314.7,3160.61 509.59,3160.61 J10.9@559,3210.02
EZFET_Vcore: C29.2 U2.17 | length 174.8
  Top Layer w12: 359.79,3543.43 U2.17@416.21,3543.43
  Top Layer w15: C29.2@254.53,3575 328.22,3575 359.79,3543.43
EZFET_VREF: C25.1 U2.9 | length 141.7
  Top Layer w12: C25.1@256.5,3725 312.05,3725 330.24,3706.82 U2.9@390.62,3706.82
EZFET_VUSB: C30.1 U2.54 | length 293.9
  Top Layer w10: v1(590,3850) 612.78,3872.78 612.78,3889.61 U2.54@613.06,3889.89 ; v1(739.23,3989.23) 770.73,3989.23 C30.1@775,3993.5
  Bottom Layer w10: v1(590,3850) 726.56,3986.56 736.56,3986.56 v1(739.23,3989.23)
EZFET_XT2IN: U2.57 Y1.1 | length 146.9
  Top Layer w10: U2.57@554,3889.89 554,3916.7 602.81,3965.51 606.54,3965.51 609.41,3968.38 Y1.1@609.41,4011.69
EZFET_XT2OUT: U2.58 Y1.3 | length 142.8
  Top Layer w10: Y1.3@491.3,4011.69 491.3,3968.38 494.17,3965.51 499.67,3965.51 534.32,3930.86 U2.58@534.32,3889.89
FAULT_STATUS: D3.2 U1.36 | length 1005.6
  Top Layer w8: v1(1335,2060) 1355,2040 D3.2@1355,1901.34
  Top Layer w10: v1@670.95,2233.05 685.79,2218.22 U1.36@685.79,2137.87
  Signal Layer 2 w10: v1(670.95,2236.84) 1071.16,2236.84 1248,2060 v1(1335,2060)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.1 C9.2 C10.2 C11.1 C12.2 C13.2 C14.2 C15.2 C16.2 C20.1 C21.2 C22.1 C23.1 C24.1 C25.2 C26.1 C27.1 C28.2 C29.1 C30.2 C31.1 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.1 C42.2 C43.2 C44.2 C45.2 C46.1 C47.2 C48.1 C49.1 C50.2 C51.1 C52.2 C53.2 C54.2 C55.2 C56.2 C59.1 D1.1 D2.1 D20.2 J4.4 J5.4 J7.2 J8.1 J9.9 J10.13 J10.14 J16.2 J17.2 J18.4 J19.4 J22.2 J23.2 J24.4 J25.4 J28.2 J29.2 L2.2 R30.2 R32.2 R43.1 R45.1 R47.1 R48.1 R49.1 R51.2 R52.2 R53.2 R60.1 R61.1 R77.1 R78.1 R80.1 R81.1 R82.1 R83.1 R84.1 R85.1 R86.1 R87.1 R88.1 R98.1 S1.3 S1.4 TP1.1 TP35.1 TP37.1 TP37.2 TP38.1 TP38.2 TP39.1 TP39.2 U1.10 U1.12 U1.15 U1.26 U1.29 U1.63 U1.76 U1.83 U1.90 U2.14 U2.16 U2.39 U2.49 U2.56 U2.65 U3.4 U3.9 U4.2 U4.3 U4.4 U4.5 U4.6 U4.7 U5.5 U5.25 U6.4 Y1.2 Y2.3 | length 1999.8
  Top Layer w8: v1(190,2380) 236.38,2380 C44.2@241.38,2375 ; v1(977.19,2442) U1.63@1029.29,2442 ; U5.25@3231.61,3101.61 v3(3270,3140) ; U5.25@3231.61,3178.39 v3(3270,3140) ; U5.5@3308.39,3252.4 3308.39,3178.39 v3(3270,3140) ; U5.25@3370,3105 3379.37,3114.37 C9.2@3485,3114.37
  Top Layer w10: U2.16@390.62,3569.02 390.89,3569.3 404.79,3569.3 442.32,3606.83 442.32,3622.32 v1(445,3625) ; U2.14@390.62,3608.39 424.6,3608.39 v1@441.21,3625 ; U1.15@421.02,2402.63 421.37,2402.98 450.88,2402.98 487.6,2439.69 487.6,2462.6 v1(490,2465) ; U1.12@421.02,2461.69 482.9,2461.69 486.21,2465 v1(490,2465) ; U1.10@421.02,2501.06 477.27,2501.06 478.53,2502.32 479.1,2502.32 480.71,2500.71 v1(485,2505) ; C49.1@455.41,2060.9 488.94,2094.43 U1.26@488.94,2137.87 489.28,2138.21 489.28,2167.72 508.88,2187.32 517.32,2187.32 v1(520,2190) 522.68,2187.32 528.05,2187.32 547.65,2167.72 547.65,2138.21 U1.29@547.99,2137.87 ; v1@480.25,2499.75 487.32,2492.68 487.32,2467.68 v1(490,2465) ; U2.65@563.84,3716.66 565.13,3717.94 565.13,3860.3 573.69,3868.86 U2.56@573.69,3889.89 ; v1(609.08,2815.31) 609.08,2819.1 616.3,2826.32 616.3,2834.8 C54.2@630,2848.5 630,2843.13 644.62,2828.51 645.61,2828.51 685.79,2788.33 U1.90@685.79,2746.13 ; v1(670,3690) 672.87,3687.13 U2.39@737.07,3687.13 ; U2.49@711.48,3889.89 U2.49@711.48,3889.89 739.94,3889.94 v1(740,3890) ; U1.83@823.58,2746.13 823.58,2700.21 835,2688.79 v1(835,2685) ; U1.76@961.38,2746.13 961.38,2745.84 962.21,2745 v1(990,2745) ; U3.4@1038.39,4144.88 1038.39,4150.59 1039.49,4151.69 1052.9,4151.69 1056.21,4155 v1(1060,4155) ; U6.4@1185,4363.62 1185,4365.59 1191.51,4372.1 1191.51,4377.24 v1(1194.19,4379.92)
  Top Layer w20: C40.2@925,4056.5 v1(925,4100) ; C39.2@1000,3993.5 1043.5,3993.5 v1(1050,4000) ; v1(2165.27,2039.16) 2165.44,2039.33 R88.1@2165.44,2071.36 ; v2(3399,3568) 3399.49,3568.49 3399.49,3600.26 R43.1@3399.98,3600.75 ; v2(4063.03,3529.52) C3.2@4063.03,3563.11 ; v2(4140,3523.09) C5.2@4140,3556.69 ; v2(4220,3523.09) C11.1@4220,3556.69 ; v2(4300,3529) C12.2@4300,3562.6
  other v1: 714,1656 1230,1685 1075,1690 1405,1690 265,1940 272,2142 150,2195 155,2295 665,2520 205,2560 175,2775 1635,3165 895,3290 640,3295 745,3295 560,3405 860,3405 570,3450 1325,3450 180,3540 1195,3545 180,3605 1020,3630 3032,3673 2638,3674 1110,3675 180,3685 1020,3720 450,3790 680,3790 129,3957 226,3957 740,4050 452,4094 1100,4095 1250,4095 740,4100 512.63,4170 919.23,4199.23 1265,4210 1095,4235 310,4250 510,4250 585,4330 705,4375 950,4375 1409,4391 900,4400 1505,4410 1555,4450 1520,4500 1440,4570
  other v2: 2901.01,2245.17 3451.01,2245.17 3051.01,2295.17 3351.01,2345.17 3451.01,2345.17 3051.01,2395.17 3351.01,2445.17 3051.01,2545.17 3051.01,2645.17 4025,2755 4201.01,2795.17 4151.01,2845.17 4251.01,2845.17 3391,2854 3465,3365 4433,3712
  other v3: 3128.27,3092.76 3175.51,3092.76 3222.76,3092.76 3270,3092.76 3317.24,3092.76 3364.49,3092.76 3411.73,3092.76 3128.27,3140 3175.51,3140 3222.76,3140 3317.24,3140 3364.49,3140 3411.73,3140 3128.27,3187.24 3175.51,3187.24 3222.76,3187.24 3270,3187.24 3317.24,3187.24 3364.49,3187.24 3411.73,3187.24
  other v4: 536.48,3642.84 591.21,3642.84 490.03,3689.3 536.48,3689.3 591.21,3689.3 637.66,3689.3 490.03,3744.02 536.48,3744.02 591.21,3744.02 637.66,3744.02 536.48,3790.48 591.21,3790.48 1000,4180.31 975.39,4200 1024.61,4200 1000,4219.69
GUI_STATUS: D10.2 U1.34 | length 709.4
  Top Layer w8: U1.34@646.42,2137.87 v1@646.42,2190.68
  Top Layer w10: D10.2@1032.04,1899.34 v1(1032.04,1962.04)
  Bottom Layer w10: v1(646.74,2191) 616,2160.26 616,2071 678,2009 861,2009 907.96,1962.04 v1(1032.04,1962.04)
ID0: R39.2 R51.1 U1.43 | length 1036.3
  Top Layer w8: v1(800,2204) 823.58,2180.42 U1.43@823.58,2137.87 ; v1(1095,2920) 1097.69,2920 1107.69,2910 1165,2910 ; R51.1@1165,2887.56 R39.2@1165,2932.44
  Bottom Layer w8: v1(800,2204) 800,2416.34 1098.87,2715.21 1098.87,2916.13 v1(1095,2920)
ID1: R40.2 R52.1 U1.44 | length 1132.3
  Top Layer w8: v1@843.27,2085.06 U1.44@843.27,2137.87 ; v1(1210,2910) 1248.48,2910 1252.2,2906.28 ; R52.1@1252.2,2882.56 1252.2,2906.28 ; R40.2@1252.2,2930 1252.2,2906.28
  Bottom Layer w8: v1(843.59,2084.73) 839.13,2089.19 839.13,2091.31 830,2100.44 830,2420.68 1210,2800.68 v1(1210,2910)
ID2: R41.2 R53.1 U1.45 | length 1038.8
  Top Layer w8: U1.45@862.95,2137.87 v1@862.95,2190.68 ; v1(1295,2910) 1334.47,2910 1335,2909.47 ; R53.1@1335,2885.75 1335,2909.47 ; R41.2@1335,2933.19 1335,2909.47
  Bottom Layer w8: v1(862.63,2191) 862.38,2191.24 862.38,2430.61 1295,2863.23 v1(1295,2910)
ID3: R30.1 R54.2 U1.46 | length 1187.1
  Top Layer w8: v1@882.64,2085.06 U1.46@882.64,2137.87 ; v1(1375,2910) 1417.97,2910 1420,2907.97 ; R30.1@1420,2884.25 1420,2907.97 ; R54.2@1420,2931.69 1420,2907.97
  Bottom Layer w8: v1(882.96,2084.73) 896,2097.77 896,2235 881.63,2249.37 881.63,2416.63 v1(1375,2910)
ID4: R31.2 R32.1 U1.47 | length 1156.9
  Top Layer w8: U1.47@902.32,2137.87 902.32,2177.32 v1(926,2201) ; v1(1465,2910) 1512.56,2910 1515,2912.44 ; R32.1@1515,2890 1515,2912.44 ; R31.2@1515,2934.88 1515,2912.44
  Bottom Layer w8: v1(926,2201) 926,2246 897.5,2274.5 897.5,2397.5 1350,2850 1405,2850 v1(1465,2910)
IN0: J7.5 TP22.1 U5.23 | length 1708
  Top Layer w8: J7.5@2025,2815 TP22.1@2156.65,2795 2335,2795 2354.29,2795 v1(2381.4,2795) v1@2390,2795 ; U5.23@3385.16,3027.6 3385.16,2986.52 v1(3421.67,2950)
  Signal Layer 2 w8: v1(2381.4,2795) 2381.4,2884.4 2487,2990 2594,2990 2705,2879 3350.67,2879 v1(3421.67,2950)
IN0_MCU: R94.1 U1.69 | length 416.8
  Top Layer w8: U1.69@1029.29,2560.11 1222.85,2560.11 1297.96,2485 R94.1@1415,2485
IN1: J7.7 TP23.1 U5.22 | length 1578
  Top Layer w8: J7.7@2025,2915 2146.65,2915 TP23.1@2161.65,2930 2164.15,2927.5 2367.5,2927.5 v1(2370,2925) ; U5.22@3359.57,3027.6 3359.78,3027.38 3359.78,2975.4 v1(3385.19,2950)
  Signal Layer 2 w8: v1(2370,2925) 2489,3044 2587,3044 2721,2910 3345.19,2910 v1(3385.19,2950)
IN1_MCU: R95.1 U1.70 | length 406.3
  Top Layer w8: U1.70@1029.29,2579.8 1242.65,2579.8 1292.45,2530 R95.1@1415,2530
MCU_3V3: C46.2 C51.2 C52.1 C53.1 C54.1 D5.2 J2.2 J7.4 J10.10 R9.2 R18.1 R19.2 R31.1 R37.1 R39.1 R40.1 R41.1 R54.1 TP36.1 U1.25 U1.64 U1.87 U1.89 | length 8605
  Top Layer w8: v1(960,2640) 960,2497.29 995.61,2461.69 U1.64@1029.29,2461.69 ; v1(1130,3015.15) 1157.6,2987.56 R39.1@1165,2987.56 ; v1(1215.42,3015.15) 1245.46,2985.12 R40.1@1252.2,2985.12 ; v1(1293.97,3015.15) 1320.82,2988.31 R41.1@1335,2988.31 ; v1(1383.68,3015.15) 1412.03,2986.81 R54.1@1420,2986.81 ; R31.1@1515,2990 1570,3045 v1(1570,3050)
  Top Layer w10: v1(175,2650) 195.16,2670.16 229.41,2670.16 232.28,2673.03 R9.2@232.28,2725 ; 317.79,2183.47 359.21,2183.47 v1(361.34,2181.34) 364.02,2184.02 376.62,2184.02 397.79,2205.19 420.43,2205.19 U1.25@421.02,2205.78 ; C54.1@630,2911.5 635.31,2906.18 664.62,2906.18 ; v1(689.23,2614.09) 691.91,2616.77 701.82,2616.77 744.87,2659.82 744.87,2691.23 744.84,2745.3 744.5,2745.64 744.5,2775.99 732.94,2787.55 708.83,2787.55 705.82,2784.54 705.82,2746.48 U1.89@705.47,2746.13 ; 704.86,2787.55 704.86,2806.7 665.57,2845.99 665.57,2905.24 664.62,2906.18 ; R18.1@725,2898.62 725,2899.37 718.19,2906.18 664.62,2906.18
  Top Layer w15: C51.2@277.84,2245.41 293.79,2245.41 317.79,2221.41 317.79,2183.47 317.79,2116.65 C53.1@328.52,2105.92 C52.1@328.52,2044.31 328.52,1983.5 C46.2@328.79,1983.23 ; C46.2@328.52,1983.23 328.52,1931.48 358.18,1901.82 386.95,1901.82 D5.2@391.87,1896.9 ; D5.2@388.54,1901.82 D5.2@396.79,1901.82 448.18,1901.82 490.37,1859.63 490.37,1714.63 630,1575 770,1575 919,1724 919,1936 1107.5,2124.5 1454.5,2124.5 1490,2160 1490,2385 1820,2715 J7.4@1925,2715 ; TP36.1@420,2935 J10.10@559,3110.02 630.92,3038.09 630.92,2911.5 C54.1@630,2911.5 ; v1(1500,3485) 1640,3625 1640,3950.11 1601.49,3988.62 R19.2@1580,3988.62
  Signal Layer 1 w10: v1(960,2640) 960,2809.82 1045,2894.82 1045,2930.15 1126.06,3011.21 v1@1130,3011.21 ; v1@1135,3011.21 v1@1135,3015
  Signal Layer 1 w15: v1(1500,3485) 1570,3415 v1(1570,3050)
  Signal Layer 2 w12: v1(175,2650) 414.16,2650 450.07,2614.09 v1(689.23,2614.09)
  Signal Layer 2 w15: J10.10@559,3110.02 654.02,3015 v1@1130,3015
  Bottom Layer w10: J2.2@160,3080 305,2935 TP36.1@420,2935 ; v1(175,2650) 175,2588.72 167.11,2580.82 167.11,2523.33 384.87,2305.56 384.87,2204.87 v1(361.34,2181.34) ; v1(1130,3015.15) v1(1215.42,3015.15) v1(1293.97,3015.15) v1(1383.68,3015.15) 1535.15,3015.15 v1(1570,3050)
MCU_STATUS: D8.2 TP19.1 U1.37 | length 327
  Top Layer w8: U1.37@705.47,2137.87 705.47,2090.53 714.26,2081.74 D8.2@714.26,1900.34 TP19.1@800,1905
MCU_UARTRXD: J10.8 U1.61 | length 888.2
  Top Layer w8: v1(800,2629.79) 800,2585.15 982.52,2402.63
  Top Layer w10: J10.8@659,3110.02 797.32,2971.7 797.32,2947.68 v1(800,2945) ; 982.52,2402.63 U1.61@1029.29,2402.63
  Signal Layer 1 w10: v1(800,2629.79) v1(800,2945)
MCU_UARTTXD: J10.6 U1.60 | length 950.1
  Top Layer w8: v1(800,2550) 967.02,2382.96
  Top Layer w10: 967.02,2382.96 U1.60@1029.28,2382.96
  Signal Layer 1 w10: J10.6@759,3110.02 880.13,2988.89 880.13,2723.83 890.08,2713.88 890.08,2640.08 v1(800,2550)
NetC15_1: C15.1 R9.1 U1.9 | length 365.8
  Top Layer w10: C15.1@281.5,2800 281.5,2740.75 267.72,2726.97 270.59,2724.09 270.59,2720.16 330.88,2659.87 330.88,2581.37 391.17,2521.09 420.68,2521.09 U1.9@421.02,2520.74
NetC26_2: C26.2 J10.1 R64.2 | length 211
  Top Layer w10: C26.2@900,3351.38 953.94,3351.38 970.16,3335.16 972.13,3335.16 R64.2@975,3332.28 ; J10.1@959,3210.02 959,3318.25 R64.2@973.03,3332.28
NetC27_2: C27.2 J10.3 R65.2 | length 236.7
  Top Layer w10: R65.2@750,3332.28 809.84,3332.28 C27.2@825,3347.44 ; C27.2@825,3351.38 C27.2@825,3347.44 ; J10.3@859,3210.02 825,3244.02 C27.2@825,3347.44
NetC38_1: C38.1 C40.1 R68.2 U3.1 | length 360.6
  Top Layer w12: R68.2@850,4147.44 850.98,4147.44 852.26,4146.16 850.81,4144.71 850.81,4113.69 885.34,4079.16 885.34,3993.5
  Top Layer w15: C38.1@850,3993.5 885.34,3993.5 920.69,3993.5 925,3997.81 C40.1@925,4001.38 ; R68.2@852.26,4146.16 960.33,4146.16 U3.1@961.61,4144.88
NetC39_1: C39.1 U3.3 | length 101.6
  Top Layer w12: C39.1@1000,4048.62 1000,4092.32 1012.8,4105.12 U3.3@1012.8,4144.88
NetC44_1: C44.1 U1.14 Y2.1 | length 180.7
  Top Layer w8: C44.1@288.62,2375 288.62,2411.32 308.54,2431.23 Y2.1@349.8,2431.23 358.72,2422.32 U1.14@421.02,2422.32
NetC45_1: C45.1 U1.13 Y2.2 | length 192.8
  Top Layer w10: C45.1@273.62,2525 273.62,2506.19 313.15,2466.66 Y2.2@349.8,2466.66 366.04,2466.66 390.36,2442.35 420.65,2442.35 U1.13@421.02,2442
NetC49_2: C49.2 U1.27 | length 79.4
  Top Layer w10: U1.27@508.62,2137.87 508.97,2137.52 508.97,2066.4 C49.2@514.47,2060.9
NetC50_1: C50.1 R37.2 U1.11 | length 275
  Top Layer w10: R37.2@267.72,2675 267.72,2648.82 281.5,2635.04 C50.1@281.5,2600 282.48,2600 343.67,2538.81 343.67,2529.21 391.17,2481.72 420.68,2481.72 U1.11@421.02,2481.37
NetD1_2: D1.2 R58.2 | length 659.7
  Top Layer w10: v1(240,3860) 241.5,3860 D1.2@275,3893.5 ; v1(330,3335) 333.79,3335 342.29,3343.5 R58.2@375,3343.5
  Signal Layer 1 w10: v1(240,3860) 240,3425 v1(330,3335)
NetD2_2: D2.2 R59.2 | length 740.9
  Top Layer w10: D2.2@175,3893.5 205,3863.5 v1(205,3860) ; v1(425,3305) 427.68,3307.68 427.68,3320.2 450,3342.52 R59.2@450,3343.5
  Bottom Layer w10: v1(205,3860) 205,3525 v1(425,3305)
NetD3_1: D3.1 R80.2 | length 71.1
  Top Layer w8: R80.2@1355,1747.56 D3.1@1355,1818.66
NetD5_1: D5.1 R49.2 | length 77.5
  Top Layer w25: R49.2@396.45,1751.62 396.62,1751.79 396.62,1828.81 D5.1@396.79,1828.98
NetD6_1: D6.1 R43.2 | length 77.3
  Top Layer w25: R43.2@3399.99,3659.81 D6.1@3399.99,3737.09
NetD8_1: D8.1 R45.2 | length 78.3
  Top Layer w25: R45.2@714.25,1749.15 714.25,1827.43 D8.1@714.29,1827.47
NetD10_1: D10.1 R47.2 | length 78.3
  Top Layer w25: R47.2@1032.04,1748.15 1032.04,1826.43 D10.1@1032.08,1826.47
NetD11_1: D11.1 R48.2 | length 78
  Top Layer w25: D11.1@1190.38,1825.92 1190.93,1825.37 R48.2@1190.93,1748.15
NetD12_1: D12.1 R81.2 | length 72
  Top Layer w8: D12.1@1680,2232.44 R81.2@1751.99,2233.63
NetD13_1: D13.1 R82.2 | length 75.7
  Top Layer w8: D13.1@1820,2231.76 1895.51,2231.76 R82.2@1895.61,2231.65
NetD14_1: D14.1 R83.2 | length 71.3
  Top Layer w8: D14.1@1955,2232.44 2023.96,2232.44 R83.2@2025.61,2234.09
NetD15_1: D15.1 R84.2 | length 70.7
  Top Layer w8: D15.1@2095,2231.76 2165.51,2231.76 R84.2@2165.61,2231.65
NetD16_1: D16.1 R85.2 | length 134.8
  Top Layer w8: D16.1@1680,2125.43 D16.1@1680.61,2125.43 ; R85.2@1744.27,2125.43 D16.1@1680.61,2125.43 ; R85.2@1750.61,2126.65 1749.39,2125.43 D16.1@1680.61,2125.43
NetD17_1: D17.1 R86.2 | length 80.5
  Top Layer w8: D17.1@1815.61,2125.43 D17.1@1820,2125.43 1894.39,2125.43 R86.2@1895.61,2126.65
NetD18_1: D18.1 R87.2 | length 139.8
  Top Layer w8: D18.1@1955,2125.43 D18.1@1955.61,2125.43 ; R87.2@2019.27,2125.43 D18.1@1955.61,2125.43 ; R87.2@2030.61,2126.65 2029.39,2125.43 D18.1@1955.61,2125.43
NetD19_1: D19.1 R88.2 | length 75.5
  Top Layer w8: D19.1@2090.61,2125.43 D19.1@2095,2125.43 2164.39,2125.43 R88.2@2165.61,2126.65
NetF1_2: F1.2 J8.2 TP2.1 | length 243
  Bottom Layer w50: TP2.1@3822,3363 4065,3363
  other v2: 4090,3160 4200,3160 4310,3160 4400,3160 4485,3160 4035,3230 4125,3235 4250,3235 4440,3240 4345,3245 4080,3310 4475,3310 4300,3315 4390,3315 4050,3405 4125,3405 4225,3405 4325,3405 4420,3405
NetJ1_1: J1.1 R1.1 | length 112.5
  Top Layer w8: J1.1@3465,2860 J1.1@3470,2855
  Top Layer w20: J1.1@3465,2860 R1.1@3465,2965.47
NetJ6_2: J6.2 S1.1 S1.2 | length 536.2
  Top Layer w15: S1.2@1142.2,3296.26 S1.1@1417.8,3296.26 1417.8,3227.71 J6.2@1282,3091.91
NetJ7_1: J7.1 TP20.1 | length 171.9
  Top Layer w8: J7.1@2025,2615 2076.65,2615 TP20.1@2161.65,2530
NetJ7_3: J7.3 TP21.1 | length 152.4
  Top Layer w8: J7.3@2025,2715 2106.65,2715 TP21.1@2156.65,2665
NetJ7_6: J7.6 R94.2 | length 599.9
  Top Layer w8: R94.2@1455,2485 1471.59,2484.39 1471.74,2484.39 1475.02,2484.39 1830.68,2815 J7.6@1925,2815
NetJ7_8: J7.8 R95.2 | length 627.6
  Top Layer w8: R95.2@1455,2530 1480.45,2529.45 1480.54,2529.45 ; 1480.58,2529.45 1483.84,2529.45 1891.85,2920.22 1905.43,2920.22 J7.8@1925,2915
NetJ7_10: J7.10 R96.2 | length 662.7
  Top Layer w8: R96.2@1455,2570 1485,2570 1785,2870 1785,2892.18 1787.53,2894.72 J7.10@1925,3015
NetJ7_14: J7.14 R92.2 | length 886.8
  Top Layer w8: R92.2@1455,2620 1500,2620 1765,2885 1765,3180 1810,3215 J7.14@1925,3215
NetJ7_16: J7.16 R91.2 | length 946.2
  Top Layer w8: R91.2@1455,2665 1500,2665 1745,2910 1745,3270 ; 1745.31,3270 1805,3315 J7.16@1925,3315
NetJ7_18: J7.18 R93.2 | length 1013.6
  Top Layer w8: R93.2@1455,2705 1500,2705 1720.87,2925.87 1720,3360 1800,3415 J7.18@1925,3415
NetJ7_20: J7.20 R90.2 | length 1080
  Top Layer w8: R90.2@1455,2745 1505,2745 1700,2940 1700,3450 1800,3515 J7.20@1925,3515
NetJ9_2: J9.2 R63.1 | length 139.6
  Top Layer w15: R63.1@775,4327.56 775.98,4327.56 833.43,4385 J9.2@833.43,4442.4
NetJ9_4: J9.4 R62.1 | length 129.3
  Top Layer w15: R62.1@700,4327.56 700.98,4327.56 733.43,4360 J9.4@733.43,4442.4
NetJ10_5: J10.5 R66.2 | length 157.1
  Top Layer w10: R66.2@675,3332.28 675,3294.02 J10.5@759,3210.02
NetJ10_7: J10.7 R67.2 | length 146.7
  Top Layer w10: R67.2@600,3332.28 600,3269.02 J10.7@659,3210.02
NetJ11_1: J11.1 L1.1 | length 118.6
  Top Layer w10: J11.1@1220.56,4469.57 1218.43,4424.79 1272.44,4375.98 L1.1@1272.44,4375
NetJ11_5: J11.5 L2.1 | length 143.7
  Top Layer w10: L2.1@1052.56,4375 1090,4375 1118.2,4403.2 J11.5@1118.2,4469.57
NetR3_1: R3.1 U4.8 | length 65.2
  Top Layer w20: U4.8@2891.57,3752.19 2891.57,3792.13 R3.1@2909.44,3810
NetR4_2: R4.2 U4.1 | length 63
  Top Layer w20: R4.2@2664.56,3810 2677,3797.56 U4.1@2677,3752.19
NetTP29_1: TP29.1 U1.42 | length 942.9
  Top Layer w10: v1(803,1975) 803.84,1975.84 803.84,2137.8 U1.42@803.9,2137.87
  Bottom Layer w10: TP29.1@170.44,1619.82 447.82,1619.82 v1(803,1975)
NetTP30_1: TP30.1 U1.16 | length 779.5
  Top Layer w10: v1(370,2382) 370.6,2382.6 420.68,2382.6 U1.16@421.02,2382.94
  Signal Layer 1 w10: TP30.1@170.44,1784.07 204.07,1784.07 235,1815 402,1977.58 402,2346.21 370,2378.21 v1(370,2382)
NetTP31_1: TP31.1 U1.88 | length 1665.9
  Top Layer w10: v1(720,2670.13) 720,2673.91 725.16,2679.07 U1.88@725.16,2746.13
  Signal Layer 1 w15: v1(118.64,2656.13) 118.64,1764.71 TP31.1@170.44,1701.94 TP31.1@172.4,1699.57
  Signal Layer 2 w12: v1(118.64,2656.13) 121.57,2656.13 141.31,2675.87 711,2675.87 716.75,2670.13 v1(720,2670.13)