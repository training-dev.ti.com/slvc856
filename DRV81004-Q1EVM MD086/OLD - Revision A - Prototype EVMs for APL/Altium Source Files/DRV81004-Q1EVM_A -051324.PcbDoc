# Altium PCB DRV81004-Q1EVM_A -051324.PcbDoc (part 4 of 4)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 4582 x 3242 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 221 components, 118 nets, 612 pads, 269 vias.

## Via types
v1: diameter 24, hole 16, Top Layer to Bottom Layer, tented both sides, 171 vias
v2: diameter 24, hole 8, Top Layer to Bottom Layer, tented both sides, 59 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 28 vias
v4: diameter 16, hole 8, Top Layer to Bottom Layer, tented both sides, 11 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
VM: C1.1 C2.1 C4.1 C8.2 C10.1 C14.1 C16.1 J12.2 J13.2 J14.2 J15.2 L3.2 TP4.1 TP6.1 TP8.1 TP10.1 TP41.1 U5.10 VM.1 | length 6080.3
  Top Layer w10: U5.10@3308.39,3025.83 3308.39,2981.61 v4(3310,2980)
  Top Layer w40: TP4.1@2613.73,4175.38 J14.2@2613.73,4521.52 ; J15.2@2810.2,1597.48 2815,1602.28 TP10.1@2815,1945 ; TP6.1@3532.57,4177.15 J12.2@3532.57,4532.35 ; J13.2@3727.72,1602.78 3733.03,1608.09 TP8.1@3733.03,1945
  Bottom Layer w40: TP4.1@2613.35,4175 2702.68,4085.68 3441.1,4085.68 TP6.1@3532.57,4177.15 3636.43,4281 3805,4281 4083.37,4002.63 4083.37,3831.37 3822,3570 TP41.1@3822,3363 ; TP10.1@2815,1945 3024.9,2154.9 3733.03,2154.9 ; TP8.1@3733.03,1945 3733.03,2154.9 ; VM.1@3819,3085 3827.28,3076.72 3827.28,2249.16 3733.03,2154.9
  other v2: 3605,2936 3705,2936 3605,3036 3705,3036 3605,3136 3705,3136 3605,3236 3705,3236 3605,3336 3705,3336 3605,3436 3705,3436
  other v4: 3312.81,2858.19 3337.81,2858.19
VS: C3.1 C5.1 C6.1 C11.2 C12.1 C13.1 D6.2 F1.1 L3.1 R3.2 R97.2 TP40.1
  other v2: 3389,3858 3464,3858 3024,3895 3009,3951 3389,3958 3464,3958
pads on no net: FID1.1 FID2.1 FID3.1 J7.11 J7.12 J9.6 J9.10 J9.12 J9.13 J9.14 J10.11 J10.12 J11.4 LBL1.0 LBL2.0 SH-J1.0 SH-J6.0 SH-J7.0 SH-J8.0 SH-J9.0 SH-J10.0 SH-J11.0 SH-J12.0 SH-J19.0 SH-J22.0 SH-J23.0 SH-J24.0 SH-J25.0 SH-J26.0 SH-J27.0 SH-J28.0 SH-J29.0 SH-J31.0 SH-J32.0 SH-J33.0 SH-J34.0 SH-J35.0 SH-J36.0 U1.1 U1.2 U1.3 U1.4 U1.5 U1.6 U1.7 U1.8 U1.17 U1.18 U1.23 U1.24 U1.28 U1.30 U1.31 U1.32 U1.33 U1.38 U1.39 U1.40 U1.41 U1.48 U1.49 U1.54 U1.55 U1.56 U1.57 U1.58 U1.59 U1.68 U1.72 U1.73 U1.74 U1.75 U1.77 U1.78 U1.79 U1.80 U1.81 U1.82 U1.84 U1.85 U1.86 U1.92 U1.93 U1.94 U1.95 U1.98 U1.99 U1.100 U2.3 U2.4 U2.5 U2.6 U2.7 U2.8 U2.10 U2.12 U2.13 U2.18 U2.19 U2.22 U2.23 U2.24 U2.25 U2.26 U2.27 U2.28 U2.29 U2.30 U2.31 U2.32 U2.33 U2.34 U2.35 U2.36 U2.41 U2.42 U2.45 U2.46 U2.47 U2.48 U3.2 U3.6 U3.7

## Polygon pours and split planes (outlines as drawn)
GND on Bottom Layer "BOTTOM_LAYER_GND_P301" (solid, remove dead copper, pour order 301): 17.16,1448.82 4586.16,1448.82 4586.16,4687.82 17.16,4687.82
NetF1_2 on Bottom Layer "BOTTOM_LAYER_NETF1_2_P284" (solid, remove dead copper, pour order 284): 4009,3140.57 4009,3428 4034,3453 4517,3453 4550,3421 4550,3140 4549.43,3140.57
VDD_3V3 on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 297): 2439,3914 2439,2741 2661,2519 3470,2519 3518,2567 3518,2756 3483,2791 2823,2791 2682,2932 2682,3921 2645,3958 2483,3958
VM on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 300): 3295,3046 3295,2848 3307,2836 3345,2836 3351,2842 3351,2913 3325,2939 3325,2961 3332,2968 3497,2968 3549,2916 3852,2916 3882,2946 3882,3451 3837,3496 3611,3496 3564,3449 3564,3094 3523,3053 3302,3053
VS on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 296): 2988,3886 3051,3823 3896,3823 3975,3902 3975,4096 3946,4125 3879,4125 3745,3991 3028,3991 2988,3951
GND on Top Layer "TOP_LAYER_GND_P298" (solid, remove dead copper, pour order 298): -1.22,4678 4580,4678 4580,1444 -9,1444
NetF1_2 on Top Layer "TOP_LAYER_NETF1_2_P288" (solid, remove dead copper, pour order 288): 3989,3449 3989,3184 4032.43,3140.57 4549.43,3140.57 4550,3140 4550,3480 4501.5,3528.5 4068.5,3528.5
VS on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 292): 3694.27,3981.97 3887,4174.7 3887,4280 3913,4306 4082,4306 4138,4250 4138,3751.04 4229.53,3662 4482,3662 4497,3647 4497,3593 4491,3587 4038,3587 3841,3784 3380.72,3784 3364,3800.72 3364,3960 3385.97,3981.97
VM on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 291): 3300,3056 3299,3055 3299,2639 3342,2596 3810,2596 3866,2652 3866,2970 3959,3063 3959,3565 3905,3619 3588,3619 3553,3584 3553,2720 3531,2698 3412,2698 3348,2762 3348,2921 3317,2952 3317,3054 3315,3056 3314,3056
VS on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 295): 2960,3971 2960,3886 2974,3872 3020,3872 3038,3890 3038,3944 3006,3976 2965,3976
VDD_3V3 on Top Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 294): 2555,3972 2543,3960 2543,3878 2558,3863 2630,3863 2639,3872 2639,3969 2636,3972
GND on Signal Layer 1 "SIGNAL_LAYER_1_GND_P184" (solid, remove dead copper, pour order 184): 15.78,4675 4577,4675 4577,1438 8,1438
GND on Signal Layer 2 "SIGNAL_LAYER_2_GND_P275" (solid, remove dead copper, pour order 275): 17.16,1448.82 4586.16,1448.82 4586.16,4687.82 17.16,4687.82

## Keep-outs
Keep-Out Layer:
  circle w10: c4744.09,255.91 r118.11
  circle w10: c255.91,255.91 r118.11
  text ".Layer_Name" at 577,-858.49 h50

## Other copper
Top Layer:
  region net VM: 3298,3055 3298,2974 3301,2971 3301,2883 3313,2871 3343,2871 3346,2874 3346,2921 3318,2949 3318,3054 3316,3056 3299,3056
  region net VDD: 3401,3055 3401,2996 3407,2990 3475,2990 3496,3011 3496,3083 3492,3087 3476,3087 3446,3057 3403,3057
  region net EZFET_USB_Shield: 958.64,4665.17 958.64,4444 1099.44,4444 1099.44,4559 1122.53,4559 1241.47,4559 1241.47,4438 1392.57,4438 1390.89,4665.17
  text ".Layer_Name" at 577,-858.49 h50
Signal Layer 1:
  text "Signal Layer 1" at 416,-862.01 h60
Signal Layer 2:
  text "Signal Layer 2" at 481,-868.01 h60
Bottom Layer:
  region net EZFET_USB_Shield: 1394.4,4425 950,4425 950,4649 1394.4,4649
  text ".Layer_Name" at 577,-858.49 h50

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  circle w10: c361.45,3864.98 r5.22
  circle w10: c961.58,4116.85 r4.47
  circle w10: c2646,3897 r5.1
  circle w10: c1145,4308 r2.83
  circle w10: c377,2678 r2.24
  lines w5: 898,4310 909,4310 909,4402 1030,4402 1030,4492 ; 909,4510 1012,4510 ; 1190.94,1928 1190.94,1938 ; 1395.68,1851.84 1425.68,1851.84 1410.68,1851.84 ; 1410.68,1841.84 1410.68,1851.84 ; 1410.68,1881.84 1410.68,1866.84 1395.68,1866.84 ; 1414.67,1833.53 1427.21,1821 ; 1417.21,1821 1427.21,1821 ; 1427.21,1831 1427.21,1821 ; 1431.95,1845.26 1443.21,1834 ; 1433.21,1834 1443.21,1834 ; 1443.21,1844 1443.21,1834 ; 1395.68,1866.84 1410.68,1851.84 ; 1395.68,1866.84 1425.68,1866.84 1410.68,1851.84 ; 1395.68,1866.84 1410.68,1851.84 ; 670,4244 670,4370 681,4370 888,4370 888,4232.78 811,4232.78 811,4244 670,4244 ; 2930.5,4530.5 2945.5,4515.5 2945.5,4545.5 2930.5,4530.5 ; 3897.22,4531.15 3912.22,4546.15 3912.22,4516.15 3897.22,4531.15
  lines w10: 2214.09,2927.5 2368.75,2926.25 ; 2215.56,3475 2360,3475 ; 2218.34,3214.86 2354.3,3214.86 ; 2219.15,3345 2355.12,3345 ; 2221.84,2795 2386.18,2795 ; 2222.5,3605.12 2361.36,3606.36 ; 2224.15,3075 2367.06,3075 ; 1834,1900 1834,2437.03 2208,2437.03 2208,1900 1834,1900 ; 3164,2930 3568,2930 3568,3450.01 3164,3450.01 3164,2930
  text "For EZFET-LITE Flashing Only" at 181,4615 h25
  text "GND" at 1891.51,4452.66 h60
  text "OUT0" at 3667.22,4055.15 h35
  text "OUT2" at 2729,4050 h35
  text "VM" at 3517.22,4044.15 h35
  text "VM" at 2571.18,4039.61 h35
  text "nSCS" at 2259,3624 h40
  text "RST" at 1225,3524 h60
  text "SCLK" at 2254,3499 h40
  text "DRV81004-Q1" at 3189,3387 h33
  text "SDI" at 2259,3369 h40
  text "GND" at 100,3250 h60
  text "SDO" at 2259,3234 h40
  text "PUSH" at 1118.91,3162.9 h25
  text "RST" at 1418.31,3157.91 h25
  text "nSLEEP" at 2249,3099 h40
  text "3" at 1096,3083 h25
  text "1" at 1454,3080 h25
  text "GND" at 4063,2997 h40 r90
  text "IN1" at 2259,2954 h40
  text "3V3" at 79,2943 h60
  text "IN0" at 2259,2814 h40
  text "GND" at 4199,2769 h40
  text "3V3" at 2249,2644 h40
  text "GND" at 2249,2509 h40
  text "DRV81004-Q1EVM_A" at 2606,2330 h50
  text "GND" at 4398,2315 h60 r90
  text "CH2" at 1932.79,2168.36 h20
  text "CH0" at 2073.42,2168.36 h20
  text "OUT3" at 2553,2042 h35
  text "OUT1" at 3481,2040 h35
  text "VM" at 3700,2040 h35
  text "MD086A" at 3805,2040 h60
  text "VM" at 2785,2037 h35
  text "CHANNEL STATUS" at 1897,1941 h35 r90
  text "CH3" at 1927,1925 h20
  text "CH1" at 2074,1925 h20
  text "GND" at 1867.56,1626.33 h60
  text "MCU_3V3" at 315.34,1612 h40 r90
  text "GUI_STATUS" at 944.34,1602 h40 r90
  text "FAULT_STATUS" at 1290.34,1598 h40 r90
  text "DRV_STATUS" at 1121.34,1596 h40 r90
  text "MCU_STATUS" at 620.34,1587 h40 r90
  text ".Layer_Name" at 577,-858.49 h50
Bottom Overlay:
  drawing of 3 lines, arcs and shapes, not listed
  text "HSX-M" at 2234,4239 h180
  text "E509426" at 2302,4072 h180
  text "94V-0" at 2075,3926 h180
  text "2420" at 2283,3795 h180
  text ".Layer_Name" at 577,-858.49 h50
Top Paste:
  text ".Layer_Name" at 577,-858.49 h50
Bottom Paste:
  text ".Layer_Name" at 577,-858.49 h50
Top Solder:
  text ".Layer_Name" at 577,-858.49 h50
  text ".Layer_Name" at 577,-858.49 h50
Bottom Solder:
  text ".Layer_Name" at 577,-858.49 h50
Drill Guide:
  text ".Layer_Name" at 577,-858.49 h50
M1 Board Outline:
  the board outline again, w10
  text ".Layer_Name" at 577,-858.49 h50
M2 Board Dimensions:
  rectangle: 0,-275 125,-150
  rectangle: 125,-400 500,-275
  lines w7: 0,-275 1000,-275 ; 125,-400 125,-150 ; 250,-400 250,-150 ; 500,-400 500,-150 ; 750,-400 750,-150 ; 0,-400 1000,-400 1000,-150 0,-150 0,-400
  text ".Layer_Name" at 577,-858.49 h50
M3 3D STEP Top:
  text ".Layer_Name" at 577,-858.49 h50
M4 3D STEP Bottom:
  text ".Layer_Name" at 577,-858.49 h50
M5 Assembly Top:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 1153.5,-318.5 h25
  text "ASSEMBLY VARIANT:" at 1153,-434 h25
  text ".VariantName" at 2189,-434 h25
  text "PCB VIEWED FROM TOP SIDE" at -228.5,-655.67 h25
  text "BOARD #:" at 2248,-655.67 h25
  text ".PRJ_Number" at 2793.5,-655.67 h25
  text "REV:" at 3638,-655.67 h25
  text ".PCB_Rev" at 3929.5,-655.67 h25
  text "SVN REV:" at 4476,-655.67 h25
  text ".VersionControl_RevNumber" at 4982,-655.67 h25
  text "TID #:" at 2248,-859 h25
  text ".TID" at 2793.5,-859 h25
  text "PLOT NAME =" at -228.5,-1064.34 h25
  text ".plot_File_Name" at 577,-1064.34 h25
  text "GENERATED    :" at 2250,-1064.34 h25
  text ".Print_Date" at 3119.5,-1064.34 h25
  text ".Print_Time" at 3848.5,-1064.34 h25
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h25
M6 Assembly Bottom:
  lines w10: -292.5,-727.33 6309.5,-727.33 ; -290.5,-930.67 6309.5,-930.67 ; 1115.5,-1140.5 1115.5,-937.67 ; 1737.5,-727.33 1737.5,-524 ; 2577.5,-727.33 2577.5,-524 ; 3844.5,-1134 3844.5,-524 ; 4733.5,-1134 6309,-1134 6309,-524 -292.5,-524 -292.5,-1134 2304.5,-1134 6309.5,-1134 6309.5,-524
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 6102,-318 h25
  text ".VariantName" at 5058,-434 h25
  text "ASSEMBLY VARIANT:" at 6097,-434 h25
  text ".VersionControl_RevNumber" at 1035.5,-656.17 h25
  text "SVN REV:" at 1541.5,-656.17 h25
  text ".PCB_Rev" at 2088,-656.17 h25
  text "REV:" at 2379.5,-656.17 h25
  text ".PRJ_Number" at 3224,-656.17 h25
  text "BOARD #:" at 3769.5,-656.17 h25
  text "PCB VIEWED FROM BOTTOM SIDE" at 6246,-656.17 h25
  text ".TID" at 3224,-859.5 h25
  text "TID #:" at 3769.5,-859.5 h25
  text "TEXAS INSTRUMENTS" at 904.5,-1064.84 h25
  text ".Print_Time" at 2169,-1064.84 h25
  text ".Print_Date" at 2898,-1064.84 h25
  text "GENERATED    :" at 3767.5,-1064.84 h25
  text ".plot_File_Name" at 5440.5,-1064.84 h25
  text "PLOT NAME =" at 6246,-1064.84 h25
M9 Title Sheet:
  drawing of 57 lines, arcs and shapes, not listed
  text "1" at 739.84,8036.5 h25
  text "2" at 3235.5,8036.5 h25
  text "3" at 5724.84,8036.5 h25
  text "4" at 8231.51,8036.5 h25
  text "5" at 10730.5,8036.5 h25
  text "6" at 13235.5,8036.5 h25
  text "A" at -416.5,6893.5 h25
  text "A" at 14383.5,6893.5 h25
  text "B" at -416.5,4513.5 h25
  text "B" at 14383.5,4513.5 h60
  text "C" at -416.5,2138.5 h25
  text "C" at 14383.5,2138.5 h60
  text "PROJECT TITLE:" at 11343.5,277.5 h60
  text "DRV81004-Q1EVM_A" at 11393.5,144.17 h60
  text "DESIGNED FOR:" at 11343.5,-23.5 h60
  text ".PRJ_Customer" at 11393.5,-163.5 h60
  text "D" at -416.5,-231.5 h25
  text "D" at 14383.5,-231.5 h60
  text "FILE NAME:" at 11343.5,-323.5 h60
  text ".PCB_File_Name_No_Path" at 11393.5,-443.5 h60
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 6374,-605.34 h25
  text "ENGINEER:" at 11343.5,-613.5 h60
  text "LAYOUT BY:" at 12848.5,-613.5 h60
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 6329.01,-718 h25
  text ".PRJ_Engineer" at 11393.5,-768.49 h60
  text "Pactron" at 12899,-768.49 h60
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 6329.01,-830.67 h25
  text ".Layer_Name" at 577,-858.49 h50
  text "ALTIUM DESIGNER VERSION:" at 12848.5,-923.5 h60
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 6329.01,-943.33 h25
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 6374,-1056 h25
  text ".print_Scale" at 11393.5,-1056.83 h60
  text ".Application_BuildNumber" at 12899,-1056.83 h60
  text "1" at 739.84,-1263.5 h25
  text "2" at 3235.5,-1263.5 h25
  text "3" at 5724.84,-1263.5 h25
  text "4" at 8231.51,-1263.5 h25
  text "5" at 10730.5,-1263.5 h60
  text "6" at 13235.5,-1263.5 h60
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 12382.02,6356.17 h60
  text "MIN. TRACK WIDTH:" at 11737.46,6224.05 h60
  text "5" at 12833.7,6224.05 h60
  text "MIL" at 12988.46,6224.05 h60
  text "5" at 12833.7,6100.93 h60
  text "MIL" at 12988.46,6100.92 h60
  text "MIN. CLEARANCE:" at 11737.46,6099.92 h60
  text "MIN. VIA PAD SIZE:" at 11737.46,5975.8 h60
  text "16" at 12803.71,5975.8 h60
  text "MIL" at 12988.46,5975.8 h60
  text "0.05mm (2MIL)" at 12432.46,5845.9 h60
  text "MINIMUM ANNULAR RING" at 11408.23,5837.67 h60
  text "EXTERNAL" at 13140.46,5837.67 h60
  text "PER" at 11608.23,5727.55 h60
  text "IPC-D-275 CLASS 2 LEVEL C" at 11828.23,5727.54 h60
  text "MIL, HOLES" at 13316.46,5627.07 h60
  text "+/-" at 12924,5618.48 h60
  text "+/-" at 13778,5618.48 h60
  text "REGISTRATION TOLERANCES:" at 11408.23,5617.42 h60
  text "METAL" at 12608,5617.42 h60
  text "5" at 13184.2,5617.42 h60
  text "3" at 14017.2,5617.42 h60
  text "MIL" at 14133.46,5617.42 h60
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 11408.23,5519.1 h60
  text "+/-" at 13778,5516.23 h60
  text "3" at 14017.2,5515.17 h60
  text "MIL" at 14133.46,5515.17 h60
  text "MATERIAL:" at 11333.46,5377.52 h60
  text "FR-4 High Tg" at 12319.9,5249 h60
  text "X" at 12175.46,5241.01 h60
  text "FR-408" at 11754.46,5236.49 h60
  text "OTHER" at 13242.46,5236.49 h60
  text "62 MIL (1.6mm) +/-10%" at 12074.56,5093.46 h60
  text "X" at 11954.46,5091.01 h60
  text "THICKNESS:" at 11408.23,5085.24 h60
  text "OTHER" at 13359.46,5085.24 h60
  text "TOLERANCE:" at 11408.23,4946.92 h60
  text "X" at 12256.46,4946.92 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4946.92 h60
  text "OTHER +/-" at 12434.46,4802.73 h60
  text "BOW & TWIST:" at 11408.23,4657.54 h60
  text "X" at 12256.46,4657.54 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4657.54 h60
  text "OTHER +/-" at 12434.46,4510.85 h60
  text "DRILLING:" at 11333.46,4380.23 h60
  text "NC_DRILL FILES" at 13094.46,4275.04 h60
  text "REFERENCE:" at 11408.23,4271.1 h60
  text "X" at 12065.46,4271.01 h60
  text "AS SHOWN" at 12243.46,4271.1 h60
  text "X" at 12966.46,4271.1 h60
  text "OTHER" at 13392.46,4128.85 h60
  text "PTH COPPER THICKNESS:" at 11407.91,4125.32 h60
  text "X" at 12547.14,4125.32 h60
  text "20-30 um" at 12675.14,4125.32 h60
  text "BOARD FINISH:" at 11333.46,3977.73 h60
  text "SILKSCREEN:" at 11488.68,3867.6 h60
  text "X" at 12446.46,3867.6 h60
  text "TOP" at 12563.46,3867.6 h60
  text "X" at 12956.46,3867.6 h60
  text "BOTTOM" at 13074.46,3867.6 h60
  text "SILKSCREEN COLOR:" at 11488.68,3712.41 h60
  text "X" at 12445.46,3712.41 h60
  text "WHITE" at 12563.46,3712.41 h60
  text "OTHER" at 13074.46,3712.41 h60
  text "X" at 12576.46,3568.96 h60
  text "GREEN" at 12694.46,3568.96 h60
  text "OTHER" at 13312.46,3568.96 h60
  text "SOLDER RESIST COLOR:" at 11488.68,3562.1 h60
  text "X" at 12576.46,3414.71 h60
  text "MATTE" at 12694.46,3414.71 h60
  text "SEMI-GLOSS" at 13312,3414.07 h60
  text "IMMERSION GOLD (ENIG)" at 12394.46,3241.94 h60
  text "ENEPIG" at 13732,3234.72 h60
  text "SURFACE FINISH:" at 11333.46,3233.72 h60
  text "X" at 12216.46,3233.72 h60
  text "IMM. TIN/SILVER OR EQUIV" at 11663,3096.4 h60
  text "OTHER" at 13094.46,3092.47 h60
  text "ARRAY/PANEL:" at 11333.46,2937.09 h60
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 12394.46,2928.87 h60
  text "X" at 12212.46,2925.9 h60
  text "N.C. ROUTE" at 12394.46,2792.9 h60
  text "V. SCORE" at 13260.46,2792.9 h60
  text "CERTIFICATION:" at 11333.46,2663.77 h60
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 12058.46,2663.77 h60
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 12058.46,2569.71 h60
  text "FAB NOTES:" at 5518.93,2557.41 h55
  text "X" at 11695.97,2441.08 h60
  text "ANSI IPC-A-600F CLASS ->" at 11823.96,2441.08 h60
  text "X" at 13471.97,2441.08 h60
  text "2" at 13581.96,2441.08 h60
  text "1" at 13266.96,2439.58 h60
  text "3" at 13935.96,2439.58 h60
  text "1. NO VENDOR LOGO OR NAME ON THE BOARD." at 5517.93,2430.72 h55
  text "2. ALL HOLES SHOULD BE FHS." at 5517.93,2308.09 h55
  text "X" at 12507.97,2293.39 h60
  text "RoHS" at 12635.96,2293.39 h60
  text "OTHER" at 13280.36,2293.39 h60
  text "PER ORDER" at 13677.42,2293.39 h60
  text "3. CLIP SILK ON NO MASK AREA." at 5521.93,2187.89 h55
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 11361,2139.57 h60
  text "4. 7.87MIL DRILLS NEED TO BE NON-CONDUCTIVE SOLDER MASK PLUGGING FROM BOTTOM SIDE" at 5520,2100 h55
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 11361,2023.5 h60
  text "5.REMOVE NON-FUNCTIONAL PADS IN INNER LAYER ." at 5523,2004 h55
  text "ADDITIONAL REQUIREMENTS:" at 11333.46,1854.08 h60
  text "MICROSECTION:" at 11408.23,1746.95 h60
  text "YES" at 12313.96,1746.95 h60
  text "REQUIRED" at 13175.46,1602.62 h60
  text "BARE BOARD ELEC. TEST:" at 11408.23,1599.76 h60
  text "NONE" at 12713.96,1599.76 h60
  text "X" at 13057.46,1599.76 h60
  text "PER ORDER" at 13767.46,1599.76 h60
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 11576.38,1394.82 h60
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 11584.38,1290.84 h60
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 11583.39,1127.46 h55
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 11575.39,891.74 h60
  text ".Layer_Name" at 577,-858.49 h50
M11 Gerber Information:
  circle w10: c4559,4935.91 r70
  circle w10: c4559,4935.91 r40
  circle w10: c4587,1286.91 r70
  circle w10: c4587,1286.91 r40
  circle w10: c-46,1274.91 r70
  circle w10: c-46,1274.91 r40
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; -146,1274.91 54,1274.91 ; -46,1174.91 -46,1374.91 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4459,4935.91 4659,4935.91 ; 4487,1286.91 4687,1286.91 ; 4559,4835.91 4559,5035.91 ; 4587,1186.91 4587,1386.91 ; 4902,-1140 4902,-937.17
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -228.5,-655.67 h50
  text "BOARD #:" at 2248,-655.67 h50
  text "REV:" at 3638,-655.67 h50
  text "A" at 3929.5,-655.67 h50
  text "SVN REV:" at 4476,-655.67 h50
  text ".VersionControl_RevNumber" at 4982,-655.67 h50
  text "DRV81004-Q1EVM_A" at 2634,-659 h50
  text "LAYER NAME =" at -228.5,-858.49 h50
  text "TID #:" at 2248,-859 h50
  text ".TID" at 2793.5,-859 h50
  text ".plot_File_Name" at 339,-1059 h35
  text "PLOT NAME =" at -228.5,-1064.34 h50
  text "GENERATED    :" at 2250,-1064.34 h50
  text ".Print_Date" at 3119.5,-1064.34 h50
  text ".Print_Time" at 3848.5,-1064.34 h50
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h50
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Stackup:" at 5479,6463.33 h70
  text "Layer" at 5538.4,6325.62 h60
  text "Name" at 5948.31,6325.62 h60
  text "Material" at 6888.05,6325.62 h60
  text "Thickness" at 7747.82,6325.62 h60
  text "Constant" at 8397.66,6325.62 h60
  text "Board Layer Stack" at 8967.52,6325.62 h60
  text "Top Overlay" at 5948.31,6205.62 h60
  text "Top Solder" at 5948.31,6085.62 h60
  text "Solder Resist" at 6888.05,6085.62 h60
  text "0.40mil" at 7747.82,6085.62 h60
  text "3.5" at 8397.66,6085.62 h60
  text "1" at 5538.4,5965.62 h60
  text "Top Layer" at 5948.31,5965.62 h60
  text "2.80mil" at 7747.82,5965.62 h60
  text "Dielectric 1" at 5948.31,5845.62 h60
  text "FR-4 High Tg" at 6888.05,5845.62 h60
  text "11.40mil" at 7747.82,5845.62 h60
  text "4.2" at 8397.66,5845.62 h60
  text "2" at 5538.4,5725.62 h60
  text "Signal Layer 1" at 5948.31,5725.62 h60
  text "1.40mil" at 7747.82,5725.62 h60
  text "Dielectric 2" at 5948.31,5605.62 h60
  text "FR-4 High Tg" at 6888.05,5605.62 h60
  text "30.00mil" at 7747.82,5605.62 h60
  text "4.2" at 8397.66,5605.62 h60
  text "3" at 5538.4,5485.62 h60
  text "Signal Layer 2" at 5948.31,5485.62 h60
  text "1.40mil" at 7747.82,5485.62 h60
  text "Dielectric 3" at 5948.31,5365.62 h60
  text "FR-4 High Tg" at 6888.05,5365.62 h60
  text "11.40mil" at 7747.82,5365.62 h60
  text "4.2" at 8397.66,5365.62 h60
  text "4" at 5538.4,5245.62 h60
  text "Bottom Layer" at 5948.31,5245.62 h60
  text "2.80mil" at 7747.82,5245.62 h60
  text "Bottom Solder" at 5948.31,5125.62 h60
  text "Solder Resist" at 6888.05,5125.62 h60
  text "0.40mil" at 7747.82,5125.62 h60
  text "3.5" at 8397.66,5125.62 h60
  text "Bottom Overlay" at 5948.31,5005.62 h60
  text "Total board thickness:" at 5538.4,4885.62 h60
  text "62.00mil" at 7747.82,4885.62 h60
  text ".Layer_Name" at 577,-858.49 h50
M13 Component Bodies Top:
  text ".Layer_Name" at 577,-858.49 h50
M14 Component Bodies Bottom:
  text ".Layer_Name" at 577,-858.49 h50
M15 Courtyards Top:
  text ".Layer_Name" at 577,-858.49 h50
M16 Courtyards Bottom:
  text ".Layer_Name" at 577,-858.49 h50
Drill Drawing:
  circle w8: c5120.37,4329.62 r12.01
  circle w8: c5120.37,4329.62 r20.02
  circle w8: c5120.37,3699.08 r20.02
  lines w8: 5100.35,3318.76 5140.38,3318.76 5140.38,3358.8 5100.35,3358.8 5100.35,3318.76 ; 5100.35,3408.84 5140.38,3408.84 5140.38,3448.87 5100.35,3448.87 5100.35,3408.84 ; 5100.35,3508.92 5110.36,3508.92 5120.37,3498.92 5130.38,3508.92 5140.38,3508.92 5130.38,3518.93 5140.38,3528.94 5130.38,3528.94 5120.37,3538.95 5110.36,3528.94 5100.35,3528.94 5110.36,3518.93 5100.35,3508.92 ; 5100.35,3588.99 5120.37,3599 5140.38,3588.99 5130.38,3609.01 5140.38,3629.03 5120.37,3619.02 5100.35,3629.03 5110.36,3609.01 5100.35,3588.99 ; 5100.35,3809.18 5140.38,3809.18 5120.37,3769.14 5100.35,3809.18 ; 5100.35,3869.23 5110.36,3869.23 5110.36,3859.22 5130.38,3859.22 5130.38,3869.23 5140.38,3869.23 5140.38,3889.24 5130.38,3889.24 5130.38,3899.25 5110.36,3899.25 5110.36,3889.24 5100.35,3889.24 5100.35,3869.23 ; 5100.35,3969.31 5120.37,3949.3 5140.38,3969.31 5120.37,3989.33 5100.35,3969.31 ; 5100.35,4039.37 5120.37,4049.38 5140.38,4039.37 5130.38,4059.39 5140.38,4079.41 5120.37,4069.4 5100.35,4079.41 5110.36,4059.39 5100.35,4039.37 ; 5100.35,4129.45 5100.35,4139.46 5110.36,4149.46 5100.35,4159.47 5100.35,4169.48 5110.36,4169.48 5120.37,4159.47 5130.38,4169.48 5140.38,4169.48 5140.38,4159.47 5130.38,4149.46 5140.38,4139.46 5140.38,4129.45 5130.38,4129.45 5120.37,4139.46 5110.36,4129.45 5100.35,4129.45 ; 5100.35,4229.53 5110.36,4229.53 5110.36,4219.52 5130.38,4219.52 5130.38,4229.53 5140.38,4229.53 5140.38,4249.55 5130.38,4249.55 5130.38,4259.56 5110.36,4259.56 5110.36,4249.55 5100.35,4249.55 5100.35,4229.53 ; 5108.36,3416.85 5132.38,3416.85 5132.38,3440.87 5108.36,3440.87 5108.36,3416.85 ; 5108.36,3597 5120.37,3603 5132.38,3597 5126.37,3609.01 5132.38,3621.02 5120.37,3615.01 5108.36,3621.02 5114.36,3609.01 5108.36,3597 ; 5108.36,3873.23 5114.36,3873.23 5114.36,3867.23 5126.37,3867.23 5126.37,3873.23 5132.38,3873.23 5132.38,3885.24 5126.37,3885.24 5126.37,3891.25 5114.36,3891.25 5114.36,3885.24 5108.36,3885.24 5108.36,3873.23
  lines w12: 5063.82,3291.74 10435.48,3291.74 ; 5063.82,4372.65 10435.48,4372.65 ; 5401.01,3201.66 5401.01,4462.73 ; 5790.42,3201.66 5790.42,4462.73 ; 6604.84,3201.66 6604.84,4462.73 ; 6915.01,3201.66 6915.01,4462.73 ; 7362.04,3201.66 7362.04,4462.73 ; 8266.53,3201.66 8266.53,4462.73 ; 8922.47,3201.66 8922.47,4462.73 ; 9586.83,3201.66 9586.83,4462.73 ; 5063.82,3201.66 10435.48,3201.66 10435.48,4462.73 5063.82,4462.73 5063.82,3201.66
  text "Drill Drawing :" at 5053,4474 h60
  text "Symbol" at 5117.87,4399.68 h43.24
  text "Quantity" at 5428.03,4399.68 h43.24
  text "Finished Hole Size" at 5817.44,4399.68 h43.24
  text "Plated" at 6631.87,4399.68 h43.24
  text "Hole Type" at 6942.03,4399.68 h43.24
  text "Drill Layer Pair" at 7389.07,4399.68 h43.24
  text "Hole Tolerance" at 8293.55,4399.68 h43.24
  text "Hole Length" at 8949.49,4399.68 h43.24
  text "Routed Path Length" at 9613.85,4399.68 h43.24
  text "28" at 5428.03,4309.6 h36.03
  text "7.87mil (0.200mm)" at 5817.44,4309.6 h36.03
  text "PTH" at 6631.87,4309.6 h36.03
  text "Round" at 6942.03,4309.6 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,4309.6 h36.03
  text "+3mil/-3mil" at 8293.55,4309.6 h36.03
  text "-" at 8949.49,4309.6 h36.03
  text "-" at 9613.85,4309.6 h36.03
  text "70" at 5428.03,4219.52 h36.03
  text "8.00mil (0.203mm)" at 5817.44,4219.52 h36.03
  text "PTH" at 6631.87,4219.52 h36.03
  text "Round" at 6942.03,4219.52 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,4219.52 h36.03
  text "+3mil/-3mil" at 8293.55,4219.52 h36.03
  text "-" at 8949.49,4219.52 h36.03
  text "-" at 9613.85,4219.52 h36.03
  text "171" at 5428.03,4129.45 h36.03
  text "16.00mil (0.406mm)" at 5817.44,4129.45 h36.03
  text "PTH" at 6631.87,4129.45 h36.03
  text "Round" at 6942.03,4129.45 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,4129.45 h36.03
  text "+3mil/-3mil" at 8293.55,4129.45 h36.03
  text "-" at 8949.49,4129.45 h36.03
  text "-" at 9613.85,4129.45 h36.03
  text "7" at 5428.03,4039.37 h36.03
  text "17.72mil (0.450mm)" at 5817.44,4039.37 h36.03
  text "PTH" at 6631.87,4039.37 h36.03
  text "Round" at 6942.03,4039.37 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,4039.37 h36.03
  text "+3mil/-3mil" at 8293.55,4039.37 h36.03
  text "-" at 8949.49,4039.37 h36.03
  text "-" at 9613.85,4039.37 h36.03
  text "34" at 5428.03,3949.3 h36.03
  text "40.00mil (1.016mm)" at 5817.44,3949.3 h36.03
  text "PTH" at 6631.87,3949.3 h36.03
  text "Round" at 6942.03,3949.3 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,3949.3 h36.03
  text "+3mil/-3mil" at 8293.55,3949.3 h36.03
  text "-" at 8949.49,3949.3 h36.03
  text "-" at 9613.85,3949.3 h36.03
  text "28" at 5428.03,3859.22 h36.03
  text "43.31mil (1.100mm)" at 5817.44,3859.22 h36.03
  text "PTH" at 6631.87,3859.22 h36.03
  text "Round" at 6942.03,3859.22 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,3859.22 h36.03
  text "+3mil/-3mil" at 8293.55,3859.22 h36.03
  text "-" at 8949.49,3859.22 h36.03
  text "-" at 9613.85,3859.22 h36.03
  text "3" at 5428.03,3769.14 h36.03
  text "45.28mil (1.150mm)" at 5817.44,3769.14 h36.03
  text "PTH" at 6631.87,3769.14 h36.03
  text "Round" at 6942.03,3769.14 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,3769.14 h36.03
  text "+3mil/-3mil" at 8293.55,3769.14 h36.03
  text "-" at 8949.49,3769.14 h36.03
  text "-" at 9613.85,3769.14 h36.03
  text "14" at 5428.03,3679.07 h36.03
  text "51.18mil (1.300mm)" at 5817.44,3679.07 h36.03
  text "PTH" at 6631.87,3679.07 h36.03
  text "Round" at 6942.03,3679.07 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,3679.07 h36.03
  text "+3mil/-3mil" at 8293.55,3679.07 h36.03
  text "-" at 8949.49,3679.07 h36.03
  text "-" at 9613.85,3679.07 h36.03
  text "2" at 5428.03,3588.99 h36.03
  text "59.06mil (1.500mm)" at 5817.44,3588.99 h36.03
  text "PTH" at 6631.87,3588.99 h36.03
  text "Round" at 6942.03,3588.99 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,3588.99 h36.03
  text "+3mil/-3mil" at 8293.55,3588.99 h36.03
  text "-" at 8949.49,3588.99 h36.03
  text "-" at 9613.85,3588.99 h36.03
  text "14" at 5428.03,3498.92 h36.03
  text "63.00mil (1.600mm)" at 5817.44,3498.92 h36.03
  text "PTH" at 6631.87,3498.92 h36.03
  text "Round" at 6942.03,3498.92 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,3498.92 h36.03
  text "+3mil/-3mil" at 8293.55,3498.92 h36.03
  text "-" at 8949.49,3498.92 h36.03
  text "-" at 9613.85,3498.92 h36.03
  text "2" at 5428.03,3408.84 h36.03
  text "25.59mil (0.650mm)" at 5817.44,3408.84 h36.03
  text "PTH" at 6631.87,3408.84 h36.03
  text "Slot" at 6942.03,3408.84 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,3408.84 h36.03
  text "+3mil/-3mil" at 8293.55,3408.84 h36.03
  text "29.53mil (0.750mm)" at 8949.49,3408.84 h36.03
  text "3.94mil (0.100mm)" at 9613.85,3408.84 h36.03
  text "2" at 5428.03,3318.76 h36.03
  text "51.18mil (1.300mm)" at 5817.44,3318.76 h36.03
  text "PTH" at 6631.87,3318.76 h36.03
  text "Slot" at 6942.03,3318.76 h36.03
  text "Top Layer - Bottom Layer" at 7389.07,3318.76 h36.03
  text "+3mil/-3mil" at 8293.55,3318.76 h36.03
  text "29.53mil (0.750mm)" at 8949.49,3318.76 h36.03
  text "-21.65mil (-0.550mm)" at 9613.85,3318.76 h36.03
  text "375 Total" at 5428.03,3228.69 h36.03
  text "Slot definitions :" at 5117.87,3137.64 h36.03
  text "Routed Path Length" at 5743.59,3137.64 h36.03
  text "= Calculated from tool start centre position to tool end centre position." at 6411.34,3137.64 h36.03
  text "Hole Length" at 5743.59,3073.61 h36.03
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 6165.21,3073.61 h36.03
  text ".Layer_Name" at 577,-858.49 h50
Mechanical 17:
  text ".Layer_Name" at 577,-858.49 h50
Mechanical 18:
  text ".Layer_Name" at 577,-858.49 h50
Mechanical 19:
  text ".Layer_Name" at 577,-858.49 h50

## Dimensions
0,-400 to 1000,-400 on M2 Board Dimensions
-1,4681 to 0,1442 on M2 Board Dimensions
-1,4681 to 4580,4678 on M2 Board Dimensions